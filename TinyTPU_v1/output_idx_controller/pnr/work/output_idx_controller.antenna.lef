

# LEF File for Accumulated Process Antenna Effects at the Boundary Pins
# *********************************************************************

VERSION 5.5 ;
NAMESCASESENSITIVE ON ;
DIVIDERCHAR "/" ;
BUSBITCHARS "[]" ;

MACRO output_idx_controller 
  PIN clk 
    ANTENNAPARTIALMETALAREA 0.054 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2112 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0498 LAYER M4 ; 
    ANTENNAMAXAREACAR 75.4759 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 330.663 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.20482 LAYER VIA4 ;
  END clk
  PIN rstn 
    ANTENNAPARTIALMETALAREA 0.0936 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.308 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0546 LAYER M4 ; 
    ANTENNAMAXAREACAR 76.8333 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 335.993 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.0989 LAYER VIA4 ;
  END rstn
  PIN alu_init 
    ANTENNAPARTIALMETALAREA 0.064 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2816 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0273 LAYER M4 ; 
    ANTENNAMAXAREACAR 114.912 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 503.267 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.8315 LAYER VIA4 ;
  END alu_init
  PIN in_valid 
    ANTENNAPARTIALMETALAREA 0.0416 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0352 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0273 LAYER M4 ; 
    ANTENNAMAXAREACAR 136.956 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 593.729 LAYER M4 ;
    ANTENNAMAXCUTCAR 2.1978 LAYER VIA4 ;
  END in_valid
  PIN row_idx[2] 
    ANTENNAPARTIALMETALAREA 2.407 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 10.5908 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2184 LAYER M4 ; 
    ANTENNAMAXAREACAR 24.5137 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 106.683 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.274725 LAYER VIA4 ;
  END row_idx[2]
  PIN row_idx[1] 
    ANTENNAPARTIALMETALAREA 2.951 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.958 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2184 LAYER M4 ; 
    ANTENNAMAXAREACAR 17.7738 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 77.2289 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.274725 LAYER VIA4 ;
  END row_idx[1]
  PIN row_idx[0] 
    ANTENNAPARTIALMETALAREA 2.892 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.6984 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2184 LAYER M4 ; 
    ANTENNAMAXAREACAR 17.3205 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 75.2344 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.274725 LAYER VIA4 ;
  END row_idx[0]
  PIN num_computation[6] 
    ANTENNAPARTIALMETALAREA 3.137 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.8028 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0546 LAYER M4 ; 
    ANTENNAMAXAREACAR 63.989 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 280.212 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.915751 LAYER VIA4 ;
  END num_computation[6]
  PIN num_computation[5] 
    ANTENNAPARTIALMETALAREA 2.434 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 10.7096 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0546 LAYER M4 ; 
    ANTENNAMAXAREACAR 62.2308 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 273.758 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.4652 LAYER VIA4 ;
  END num_computation[5]
  PIN num_computation[4] 
    ANTENNAPARTIALMETALAREA 3.249 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 14.3132 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0546 LAYER M4 ; 
    ANTENNAMAXAREACAR 73.4689 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 319.934 LAYER M4 ;
    ANTENNAMAXCUTCAR 2.9304 LAYER VIA4 ;
  END num_computation[4]
  PIN num_computation[3] 
    ANTENNAPARTIALMETALAREA 2.967 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.0548 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0246 LAYER M4 ; 
    ANTENNAMAXAREACAR 131.37 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 573.862 LAYER M4 ;
    ANTENNAMAXCUTCAR 2.43902 LAYER VIA4 ;
  END num_computation[3]
  PIN num_computation[2] 
    ANTENNAPARTIALMETALAREA 1.797 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 7.9068 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0702 LAYER M4 ; 
    ANTENNAMAXAREACAR 55.4917 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 242.47 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.3024 LAYER VIA4 ;
  END num_computation[2]
  PIN num_computation[1] 
    ANTENNAPARTIALMETALAREA 2.827 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.4388 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0975 LAYER M4 ; 
    ANTENNAMAXAREACAR 46.7319 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 203.971 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.30403 LAYER VIA4 ;
  END num_computation[1]
  PIN num_computation[0] 
    ANTENNAPARTIALMETALAREA 2.757 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.1308 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1506 LAYER M4 ; 
    ANTENNAMAXAREACAR 40.6006 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 174.44 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.75882 LAYER VIA4 ;
  END num_computation[0]
  PIN m[6] 
    ANTENNAPARTIALMETALAREA 3.627 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 15.9588 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0546 LAYER M4 ; 
    ANTENNAMAXAREACAR 86.2784 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 376.564 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.4652 LAYER VIA4 ;
  END m[6]
  PIN m[5] 
    ANTENNAPARTIALMETALAREA 3.697 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 16.2668 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0546 LAYER M4 ; 
    ANTENNAMAXAREACAR 72.4744 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 317.626 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.0989 LAYER VIA4 ;
  END m[5]
  PIN m[4] 
    ANTENNAPARTIALMETALAREA 3.975 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 17.534 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0546 LAYER M4 ; 
    ANTENNAMAXAREACAR 81.5165 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 358.132 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.4652 LAYER VIA4 ;
  END m[4]
  PIN m[3] 
    ANTENNAPARTIALMETALAREA 3.964 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 17.4416 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0546 LAYER M4 ; 
    ANTENNAMAXAREACAR 92.6337 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 407.048 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.8315 LAYER VIA4 ;
  END m[3]
  PIN m[2] 
    ANTENNAPARTIALMETALAREA 4.254 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 18.7176 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0546 LAYER M4 ; 
    ANTENNAMAXAREACAR 92.881 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 406.095 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.0989 LAYER VIA4 ;
  END m[2]
  PIN m[1] 
    ANTENNAPARTIALMETALAREA 4.337 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 19.0828 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0813 LAYER M4 ; 
    ANTENNAMAXAREACAR 75.3679 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 324.256 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.74413 LAYER VIA4 ;
  END m[1]
  PIN m[0] 
    ANTENNAPARTIALMETALAREA 0.816 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.6344 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0273 LAYER M4 ; 
    ANTENNAMAXAREACAR 35.7784 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 158.505 LAYER M4 ;
    ANTENNAMAXCUTCAR 2.1978 LAYER VIA4 ;
  END m[0]
  PIN k[6] 
    ANTENNAPARTIALMETALAREA 3.837 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 16.8828 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0546 LAYER M4 ; 
    ANTENNAMAXAREACAR 83.7821 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 365.465 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.8315 LAYER VIA4 ;
  END k[6]
  PIN k[5] 
    ANTENNAPARTIALMETALAREA 4.083 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 17.8948 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1092 LAYER M4 ; 
    ANTENNAMAXAREACAR 52.4597 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 228.59 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.64835 LAYER VIA4 ;
  END k[5]
  PIN k[4] 
    ANTENNAPARTIALMETALAREA 4.551 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 19.998 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1458 LAYER M4 ; 
    ANTENNAMAXAREACAR 40.0595 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 175.297 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.60238 LAYER VIA4 ;
  END k[4]
  PIN k[3] 
    ANTENNAPARTIALMETALAREA 4.634 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 20.3896 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1458 LAYER M4 ; 
    ANTENNAMAXAREACAR 45.0757 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 195.389 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.00695 LAYER VIA4 ;
  END k[3]
  PIN k[2] 
    ANTENNAPARTIALMETALAREA 4.657 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 20.4908 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1458 LAYER M4 ; 
    ANTENNAMAXAREACAR 38.2133 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 167.896 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.60238 LAYER VIA4 ;
  END k[2]
  PIN k[1] 
    ANTENNAPARTIALMETALAREA 4.363 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 19.1268 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1458 LAYER M4 ; 
    ANTENNAMAXAREACAR 41.5633 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 180.703 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.23608 LAYER VIA4 ;
  END k[1]
  PIN k[0] 
    ANTENNAPARTIALMETALAREA 4.073 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 17.8508 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1065 LAYER M4 ; 
    ANTENNAMAXAREACAR 56.1176 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 245.633 LAYER M4 ;
    ANTENNAMAXCUTCAR 2.7519 LAYER VIA4 ;
  END k[0]
  PIN c_row_idx[8] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.088 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.3872 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0246 LAYER M4 ; 
    ANTENNAMAXAREACAR 164.63 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 724.138 LAYER M4 ;
    ANTENNAMAXCUTCAR 2.43902 LAYER VIA4 ;
  END c_row_idx[8]
  PIN c_row_idx[7] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.777 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.2188 LAYER M4 ;
  END c_row_idx[7]
  PIN c_row_idx[6] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.287 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 14.4628 LAYER M4 ;
  END c_row_idx[6]
  PIN c_row_idx[5] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.477 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 15.2988 LAYER M4 ;
  END c_row_idx[5]
  PIN c_row_idx[4] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 5.183 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 22.7348 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.054 LAYER M4 ; 
    ANTENNAMAXAREACAR 127.62 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 561.67 LAYER M4 ;
    ANTENNAMAXCUTCAR 2.20187 LAYER VIA4 ;
  END c_row_idx[4]
  PIN c_row_idx[3] 
    ANTENNADIFFAREA 0.9987 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 6.047 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 26.51 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0822 LAYER M4 ; 
    ANTENNAMAXAREACAR 111.775 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 487.056 LAYER M4 ;
    ANTENNAMAXCUTCAR 3.2967 LAYER VIA4 ;
  END c_row_idx[3]
  PIN c_row_idx[2] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 6.701 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 29.5724 LAYER M4 ;
  END c_row_idx[2]
  PIN c_row_idx[1] 
    ANTENNAPARTIALMETALAREA 6.597 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 29.0268 LAYER M4 ;
    ANTENNAPARTIALCUTAREA 0.02 LAYER VIA4 ;
    ANTENNADIFFAREA 1.092 LAYER M5 ; 
    ANTENNAPARTIALMETALAREA 3.414 LAYER M5 ;
    ANTENNAPARTIALMETALSIDEAREA 14.9952 LAYER M5 ;
  END c_row_idx[1]
  PIN c_row_idx[0] 
    ANTENNAPARTIALMETALAREA 6.787 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 29.8628 LAYER M4 ;
    ANTENNAPARTIALCUTAREA 0.02 LAYER VIA4 ;
    ANTENNADIFFAREA 1.092 LAYER M5 ; 
    ANTENNAPARTIALMETALAREA 3.394 LAYER M5 ;
    ANTENNAPARTIALMETALSIDEAREA 14.9072 LAYER M5 ;
  END c_row_idx[0]
  PIN c_col_idx[8] 
    ANTENNADIFFAREA 0.9987 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.469 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 15.3076 LAYER M4 ;
  END c_col_idx[8]
  PIN c_col_idx[7] 
    ANTENNADIFFAREA 0.9987 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.115 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.6796 LAYER M4 ;
  END c_col_idx[7]
  PIN c_col_idx[6] 
    ANTENNADIFFAREA 0.9987 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.165 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.8996 LAYER M4 ;
  END c_col_idx[6]
  PIN c_col_idx[5] 
    ANTENNADIFFAREA 0.9987 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.779 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.2716 LAYER M4 ;
  END c_col_idx[5]
  PIN c_col_idx[4] 
    ANTENNADIFFAREA 0.9987 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.949 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.0196 LAYER M4 ;
  END c_col_idx[4]
  PIN c_col_idx[3] 
    ANTENNADIFFAREA 0.9987 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.981 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.2044 LAYER M4 ;
  END c_col_idx[3]
  PIN c_col_idx[2] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.089 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.6356 LAYER M4 ;
  END c_col_idx[2]
  PIN c_col_idx[1] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.719 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.0076 LAYER M4 ;
  END c_col_idx[1]
  PIN c_col_idx[0] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.149 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.8996 LAYER M4 ;
  END c_col_idx[0]
  PIN done_flag 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.0416 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0352 LAYER M4 ;
  END done_flag
END output_idx_controller

END LIBRARY
