

# LEF File for Accumulated Process Antenna Effects at the Boundary Pins
# *********************************************************************

VERSION 5.5 ;
NAMESCASESENSITIVE ON ;
DIVIDERCHAR "/" ;
BUSBITCHARS "[]" ;

MACRO input_idx_controller 
  PIN clk 
    ANTENNAPARTIALMETALAREA 0.672 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 2.9744 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0498 LAYER M4 ; 
    ANTENNAMAXAREACAR 17.8454 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 78.2289 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.20482 LAYER VIA4 ;
  END clk
  PIN rstn 
    ANTENNAPARTIALMETALAREA 0.0936 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.308 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0498 LAYER M4 ; 
    ANTENNAMAXAREACAR 73.3534 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 317.293 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.20482 LAYER VIA4 ;
  END rstn
  PIN tpu_start 
    ANTENNAPARTIALMETALAREA 0.0416 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0352 LAYER M4 ;
    ANTENNAPARTIALCUTAREA 0.02 LAYER VIA4 ;
    ANTENNAPARTIALMETALAREA 6.514 LAYER M5 ;
    ANTENNAPARTIALMETALSIDEAREA 28.6352 LAYER M5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1044 LAYER M5 ; 
    ANTENNAMAXAREACAR 86.0422 LAYER M5 ;
    ANTENNAMAXSIDEAREACAR 376.582 LAYER M5 ;
    ANTENNAMAXCUTCAR 1.29047 LAYER VIA5 ;
  END tpu_start
  PIN num_computation[6] 
    ANTENNAPARTIALMETALAREA 2.611 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 11.4884 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0546 LAYER M4 ; 
    ANTENNAMAXAREACAR 85.1245 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 373.209 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.0989 LAYER VIA4 ;
  END num_computation[6]
  PIN num_computation[5] 
    ANTENNAPARTIALMETALAREA 2.397 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 10.5468 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0546 LAYER M4 ; 
    ANTENNAMAXAREACAR 93.4212 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 408.74 LAYER M4 ;
    ANTENNAMAXCUTCAR 2.1978 LAYER VIA4 ;
  END num_computation[5]
  PIN num_computation[4] 
    ANTENNAPARTIALMETALAREA 2.467 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 10.8548 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0546 LAYER M4 ; 
    ANTENNAMAXAREACAR 79.5018 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 346.747 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.0989 LAYER VIA4 ;
  END num_computation[4]
  PIN num_computation[3] 
    ANTENNAPARTIALMETALAREA 2.817 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.3948 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0246 LAYER M4 ; 
    ANTENNAMAXAREACAR 121.37 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 532.724 LAYER M4 ;
    ANTENNAMAXCUTCAR 2.43902 LAYER VIA4 ;
  END num_computation[3]
  PIN num_computation[2] 
    ANTENNAPARTIALMETALAREA 2.767 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.1748 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0702 LAYER M4 ; 
    ANTENNAMAXAREACAR 63.6561 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 278.376 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.7501 LAYER VIA4 ;
  END num_computation[2]
  PIN num_computation[1] 
    ANTENNAPARTIALMETALAREA 2.717 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 11.9548 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0975 LAYER M4 ; 
    ANTENNAMAXAREACAR 48.1663 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 210.611 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.30403 LAYER VIA4 ;
  END num_computation[1]
  PIN num_computation[0] 
    ANTENNAPARTIALMETALAREA 2.667 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 11.7348 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1506 LAYER M4 ; 
    ANTENNAMAXAREACAR 40.5963 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 177.208 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.32246 LAYER VIA4 ;
  END num_computation[0]
  PIN m[6] 
    ANTENNAPARTIALMETALAREA 2.837 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.4828 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0546 LAYER M4 ; 
    ANTENNAMAXAREACAR 66.7546 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 291.949 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.4652 LAYER VIA4 ;
  END m[6]
  PIN m[5] 
    ANTENNAPARTIALMETALAREA 3.543 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 15.5188 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0546 LAYER M4 ; 
    ANTENNAMAXAREACAR 75.2161 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 329.604 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.4652 LAYER VIA4 ;
  END m[5]
  PIN m[4] 
    ANTENNAPARTIALMETALAREA 3.117 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.7148 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0546 LAYER M4 ; 
    ANTENNAMAXAREACAR 67.3462 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 294.037 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.0989 LAYER VIA4 ;
  END m[4]
  PIN m[3] 
    ANTENNAPARTIALMETALAREA 1.827 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 8.0388 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0546 LAYER M4 ; 
    ANTENNAMAXAREACAR 78.3443 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 339.465 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.4652 LAYER VIA4 ;
  END m[3]
  PIN m[2] 
    ANTENNAPARTIALMETALAREA 1.893 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 8.2588 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0546 LAYER M4 ; 
    ANTENNAMAXAREACAR 63.6777 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 278.835 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.4652 LAYER VIA4 ;
  END m[2]
  PIN m[1] 
    ANTENNAPARTIALMETALAREA 3.347 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 14.7268 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0546 LAYER M4 ; 
    ANTENNAMAXAREACAR 71.8571 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 312.491 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.8315 LAYER VIA4 ;
  END m[1]
  PIN m[0] 
    ANTENNAPARTIALMETALAREA 2.817 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.3948 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0273 LAYER M4 ; 
    ANTENNAMAXAREACAR 121.603 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 531.941 LAYER M4 ;
    ANTENNAMAXCUTCAR 2.1978 LAYER VIA4 ;
  END m[0]
  PIN n[6] 
    ANTENNAPARTIALMETALAREA 4.709 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 20.7636 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0546 LAYER M4 ; 
    ANTENNAMAXAREACAR 104.383 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 457.48 LAYER M4 ;
    ANTENNAMAXCUTCAR 2.1978 LAYER VIA4 ;
  END n[6]
  PIN n[5] 
    ANTENNAPARTIALMETALAREA 4.677 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 20.5788 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1092 LAYER M4 ; 
    ANTENNAMAXAREACAR 57.4164 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 250.319 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.64835 LAYER VIA4 ;
  END n[5]
  PIN n[4] 
    ANTENNAPARTIALMETALAREA 4.787 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 21.0628 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1458 LAYER M4 ; 
    ANTENNAMAXAREACAR 43.491 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 190.688 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.23608 LAYER VIA4 ;
  END n[4]
  PIN n[3] 
    ANTENNAPARTIALMETALAREA 5.273 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 23.1308 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1458 LAYER M4 ; 
    ANTENNAMAXAREACAR 45.0865 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 195.869 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.869775 LAYER VIA4 ;
  END n[3]
  PIN n[2] 
    ANTENNAPARTIALMETALAREA 4.667 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 20.5348 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1458 LAYER M4 ; 
    ANTENNAMAXAREACAR 50.5239 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 222.209 LAYER M4 ;
    ANTENNAMAXCUTCAR 2.33498 LAYER VIA4 ;
  END n[2]
  PIN n[1] 
    ANTENNAPARTIALMETALAREA 4.777 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 21.0188 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1458 LAYER M4 ; 
    ANTENNAMAXAREACAR 41.6603 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 181.778 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.60238 LAYER VIA4 ;
  END n[1]
  PIN n[0] 
    ANTENNAPARTIALMETALAREA 4.693 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 20.6668 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1326 LAYER M4 ; 
    ANTENNAMAXAREACAR 71.5387 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 310.039 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.96581 LAYER VIA4 ;
  END n[0]
  PIN k[6] 
    ANTENNAPARTIALMETALAREA 2.933 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.8348 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0273 LAYER M4 ; 
    ANTENNAMAXAREACAR 174.35 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 764.029 LAYER M4 ;
    ANTENNAMAXCUTCAR 2.1978 LAYER VIA4 ;
  END k[6]
  PIN k[5] 
    ANTENNAPARTIALMETALAREA 2.427 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 10.6788 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1092 LAYER M4 ; 
    ANTENNAMAXAREACAR 45.2344 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 197.645 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.28205 LAYER VIA4 ;
  END k[5]
  PIN k[4] 
    ANTENNAPARTIALMETALAREA 3.938 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 17.3712 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1458 LAYER M4 ; 
    ANTENNAMAXAREACAR 35.3221 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 153.982 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.60238 LAYER VIA4 ;
  END k[4]
  PIN k[3] 
    ANTENNAPARTIALMETALAREA 4.289 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 18.9156 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1458 LAYER M4 ; 
    ANTENNAMAXAREACAR 42.9407 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 183.843 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.73955 LAYER VIA4 ;
  END k[3]
  PIN k[2] 
    ANTENNAPARTIALMETALAREA 4.555 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 20.086 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1458 LAYER M4 ; 
    ANTENNAMAXAREACAR 40.6408 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 179.207 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.60238 LAYER VIA4 ;
  END k[2]
  PIN k[1] 
    ANTENNAPARTIALMETALAREA 4.489 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 19.7956 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1458 LAYER M4 ; 
    ANTENNAMAXAREACAR 36.6863 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 160.98 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.00695 LAYER VIA4 ;
  END k[1]
  PIN k[0] 
    ANTENNAPARTIALMETALAREA 3.835 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 16.918 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1053 LAYER M4 ; 
    ANTENNAMAXAREACAR 69.5062 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 301.162 LAYER M4 ;
    ANTENNAMAXCUTCAR 2.75404 LAYER VIA4 ;
  END k[0]
  PIN a_row_idx[8] 
    ANTENNADIFFAREA 0.9987 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.799 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.3596 LAYER M4 ;
  END a_row_idx[8]
  PIN a_row_idx[7] 
    ANTENNADIFFAREA 0.9987 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.749 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.1396 LAYER M4 ;
  END a_row_idx[7]
  PIN a_row_idx[6] 
    ANTENNADIFFAREA 0.9987 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.939 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.9756 LAYER M4 ;
  END a_row_idx[6]
  PIN a_row_idx[5] 
    ANTENNADIFFAREA 0.9987 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.329 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 14.6916 LAYER M4 ;
  END a_row_idx[5]
  PIN a_row_idx[4] 
    ANTENNADIFFAREA 0.9987 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.139 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.8556 LAYER M4 ;
  END a_row_idx[4]
  PIN a_row_idx[3] 
    ANTENNADIFFAREA 0.9987 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.769 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.2276 LAYER M4 ;
  END a_row_idx[3]
  PIN a_row_idx[2] 
    ANTENNADIFFAREA 0.9987 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.839 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.5356 LAYER M4 ;
  END a_row_idx[2]
  PIN a_row_idx[1] 
    ANTENNADIFFAREA 1.005 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.889 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.7556 LAYER M4 ;
  END a_row_idx[1]
  PIN a_row_idx[0] 
    ANTENNADIFFAREA 0.9987 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.959 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.0636 LAYER M4 ;
  END a_row_idx[0]
  PIN a_col_idx[8] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 5.617 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 24.7148 LAYER M4 ;
  END a_col_idx[8]
  PIN a_col_idx[7] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 5.569 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 24.5476 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0819 LAYER M4 ; 
    ANTENNAMAXAREACAR 88.6935 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 388.188 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.7094 LAYER VIA4 ;
  END a_col_idx[7]
  PIN a_col_idx[6] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 5.637 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 24.8028 LAYER M4 ;
  END a_col_idx[6]
  PIN a_col_idx[5] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 6.345 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 27.962 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0273 LAYER M4 ; 
    ANTENNAMAXAREACAR 247.518 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 1087.71 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.8315 LAYER VIA4 ;
  END a_col_idx[5]
  PIN a_col_idx[4] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 5.357 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 23.5708 LAYER M4 ;
  END a_col_idx[4]
  PIN a_col_idx[3] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 6.464 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 28.3448 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0831 LAYER M4 ; 
    ANTENNAMAXAREACAR 122.013 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 533.957 LAYER M4 ;
    ANTENNAMAXCUTCAR 2.9304 LAYER VIA4 ;
  END a_col_idx[3]
  PIN a_col_idx[2] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.843 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.5268 LAYER M4 ;
  END a_col_idx[2]
  PIN a_col_idx[1] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.139 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.8556 LAYER M4 ;
  END a_col_idx[1]
  PIN a_col_idx[0] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.929 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.9316 LAYER M4 ;
  END a_col_idx[0]
  PIN b_row_idx[8] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.663 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 16.0468 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0819 LAYER M4 ; 
    ANTENNAMAXAREACAR 62.8779 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 275.59 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.3431 LAYER VIA4 ;
  END b_row_idx[8]
  PIN b_row_idx[7] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 4.017 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 17.6748 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0546 LAYER M4 ; 
    ANTENNAMAXAREACAR 86.152 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 377.319 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.0989 LAYER VIA4 ;
  END b_row_idx[7]
  PIN b_row_idx[6] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 4.067 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 17.8948 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0513 LAYER M4 ; 
    ANTENNAMAXAREACAR 105.11 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 460.065 LAYER M4 ;
    ANTENNAMAXCUTCAR 2.01588 LAYER VIA4 ;
  END b_row_idx[6]
  PIN b_row_idx[5] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 4.057 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 17.8508 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0786 LAYER M4 ; 
    ANTENNAMAXAREACAR 80.988 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 353.827 LAYER M4 ;
    ANTENNAMAXCUTCAR 2.69348 LAYER VIA4 ;
  END b_row_idx[5]
  PIN b_row_idx[4] 
    ANTENNADIFFAREA 0.9987 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.783 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 16.5748 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0927 LAYER M4 ; 
    ANTENNAMAXAREACAR 54.7497 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 239.267 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.68095 LAYER VIA4 ;
  END b_row_idx[4]
  PIN b_row_idx[3] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.433 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 15.0348 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.078 LAYER M4 ; 
    ANTENNAMAXAREACAR 99.6709 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 432.391 LAYER M4 ;
    ANTENNAMAXCUTCAR 2.82051 LAYER VIA4 ;
  END b_row_idx[3]
  PIN b_row_idx[2] 
    ANTENNADIFFAREA 0.9987 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.719 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.0076 LAYER M4 ;
  END b_row_idx[2]
  PIN b_row_idx[1] 
    ANTENNADIFFAREA 1.0647 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.105 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.6356 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.3015 LAYER M4 ; 
    ANTENNAMAXAREACAR 30.3523 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 129.544 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.89784 LAYER VIA4 ;
  END b_row_idx[1]
  PIN b_row_idx[0] 
    ANTENNADIFFAREA 0.9987 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.139 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.8556 LAYER M4 ;
  END b_row_idx[0]
  PIN b_col_idx[8] 
    ANTENNADIFFAREA 0.9987 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.549 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 11.2596 LAYER M4 ;
  END b_col_idx[8]
  PIN b_col_idx[7] 
    ANTENNADIFFAREA 0.9987 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.523 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 11.1452 LAYER M4 ;
  END b_col_idx[7]
  PIN b_col_idx[6] 
    ANTENNADIFFAREA 0.9987 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.649 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 11.6996 LAYER M4 ;
  END b_col_idx[6]
  PIN b_col_idx[5] 
    ANTENNADIFFAREA 0.9987 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.359 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 14.8236 LAYER M4 ;
  END b_col_idx[5]
  PIN b_col_idx[4] 
    ANTENNADIFFAREA 0.9987 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.038 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2112 LAYER M4 ;
  END b_col_idx[4]
  PIN b_col_idx[3] 
    ANTENNADIFFAREA 0.9987 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.539 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 15.6156 LAYER M4 ;
  END b_col_idx[3]
  PIN b_col_idx[2] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.949 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.0196 LAYER M4 ;
  END b_col_idx[2]
  PIN b_col_idx[1] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.159 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.9436 LAYER M4 ;
  END b_col_idx[1]
  PIN b_col_idx[0] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.349 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 14.7796 LAYER M4 ;
  END b_col_idx[0]
  PIN alu_start 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.0416 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0352 LAYER M4 ;
  END alu_start
  PIN sram_rd_en 
    ANTENNADIFFAREA 1.005 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.0936 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.308 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0552 LAYER M4 ; 
    ANTENNAMAXAREACAR 107.368 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 465.584 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.45724 LAYER VIA4 ;
  END sram_rd_en
  PIN done 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.0416 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0352 LAYER M4 ;
  END done
END input_idx_controller

END LIBRARY
