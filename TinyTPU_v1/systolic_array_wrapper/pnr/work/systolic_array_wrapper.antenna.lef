

# LEF File for Accumulated Process Antenna Effects at the Boundary Pins
# *********************************************************************

VERSION 5.5 ;
NAMESCASESENSITIVE ON ;
DIVIDERCHAR "/" ;
BUSBITCHARS "[]" ;

MACRO systolic_array_wrapper 
  PIN clk 
    ANTENNAPARTIALMETALAREA 0.054 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2112 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0498 LAYER M4 ; 
    ANTENNAMAXAREACAR 76.2791 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 334.197 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.20482 LAYER VIA4 ;
  END clk
  PIN rstn 
    ANTENNAPARTIALMETALAREA 0.0936 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.308 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0546 LAYER M4 ; 
    ANTENNAMAXAREACAR 65.3718 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 285.799 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.0989 LAYER VIA4 ;
  END rstn
  PIN alu_start 
    ANTENNAPARTIALMETALAREA 0.0416 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0352 LAYER M4 ;
    ANTENNAPARTIALCUTAREA 0.02 LAYER VIA4 ;
    ANTENNAPARTIALMETALAREA 2.794 LAYER M5 ;
    ANTENNAPARTIALMETALSIDEAREA 12.2672 LAYER M5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0546 LAYER M5 ; 
    ANTENNAMAXAREACAR 57.8819 LAYER M5 ;
    ANTENNAMAXSIDEAREACAR 254.89 LAYER M5 ;
    ANTENNAMAXCUTCAR 1.4652 LAYER VIA5 ;
  END alu_start
  PIN all_input_are_fed 
    ANTENNAPARTIALMETALAREA 0.0936 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.308 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0546 LAYER M4 ; 
    ANTENNAMAXAREACAR 70.9725 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 310.205 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.0989 LAYER VIA4 ;
  END all_input_are_fed
  PIN keep_pe_value 
    ANTENNAPARTIALMETALAREA 0.0416 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0352 LAYER M4 ;
    ANTENNAPARTIALCUTAREA 0.02 LAYER VIA4 ;
    ANTENNAPARTIALMETALAREA 3.954 LAYER M5 ;
    ANTENNAPARTIALMETALSIDEAREA 17.3712 LAYER M5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0498 LAYER M5 ; 
    ANTENNAMAXAREACAR 198.675 LAYER M5 ;
    ANTENNAMAXSIDEAREACAR 872.161 LAYER M5 ;
    ANTENNAMAXCUTCAR 1.40562 LAYER VIA5 ;
  END keep_pe_value
  PIN tile_num[5] 
    ANTENNAPARTIALMETALAREA 0.0416 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0352 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1092 LAYER M4 ; 
    ANTENNAMAXAREACAR 48.0916 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 208.996 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.732601 LAYER VIA4 ;
  END tile_num[5]
  PIN tile_num[4] 
    ANTENNAPARTIALMETALAREA 0.0416 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0352 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0753 LAYER M4 ; 
    ANTENNAMAXAREACAR 72.4944 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 313.721 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.71488 LAYER VIA4 ;
  END tile_num[4]
  PIN tile_num[3] 
    ANTENNAPARTIALMETALAREA 2.9996 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.0944 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.078 LAYER M4 ; 
    ANTENNAMAXAREACAR 41.9872 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 181.605 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.769231 LAYER VIA4 ;
  END tile_num[3]
  PIN tile_num[2] 
    ANTENNAPARTIALMETALAREA 3.7796 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 16.5264 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0753 LAYER M4 ; 
    ANTENNAMAXAREACAR 58.6398 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 253.696 LAYER M4 ;
    ANTENNAMAXCUTCAR 2.19797 LAYER VIA4 ;
  END tile_num[2]
  PIN tile_num[1] 
    ANTENNAPARTIALMETALAREA 4.5196 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 19.7824 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.078 LAYER M4 ; 
    ANTENNAMAXAREACAR 65.059 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 282.61 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.53846 LAYER VIA4 ;
  END tile_num[1]
  PIN tile_num[0] 
    ANTENNAPARTIALMETALAREA 2.6856 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 11.5368 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.3158 LAYER M4 ; 
    ANTENNAMAXAREACAR 107.631 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 470.788 LAYER M4 ;
    ANTENNAPARTIALCUTAREA 0.02 LAYER VIA4 ;
    ANTENNAMAXCUTCAR 3.78286 LAYER VIA4 ;
    ANTENNAPARTIALMETALAREA 0.124 LAYER M5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.4488 LAYER M5 ;
    ANTENNAGATEAREA 1.3158 LAYER M5 ; 
    ANTENNAMAXAREACAR 107.725 LAYER M5 ;
    ANTENNAMAXSIDEAREACAR 471.129 LAYER M5 ;
    ANTENNAPARTIALCUTAREA 0.02 LAYER VIA5 ;
    ANTENNAMAXCUTCAR 3.79806 LAYER VIA5 ;
    ANTENNAPARTIALMETALAREA 0.558 LAYER M6 ;
    ANTENNAPARTIALMETALSIDEAREA 2.4992 LAYER M6 ;
    ANTENNAGATEAREA 1.3158 LAYER M6 ; 
    ANTENNAMAXAREACAR 108.149 LAYER M6 ;
    ANTENNAMAXSIDEAREACAR 473.028 LAYER M6 ;
    ANTENNAPARTIALCUTAREA 0.02 LAYER VIA6 ;
    ANTENNAMAXCUTCAR 3.81326 LAYER VIA6 ;
    ANTENNAPARTIALMETALAREA 14.45 LAYER M7 ;
    ANTENNAPARTIALMETALSIDEAREA 63.4832 LAYER M7 ;
    ANTENNAGATEAREA 1.3665 LAYER M7 ; 
    ANTENNAMAXAREACAR 320.809 LAYER M7 ;
    ANTENNAMAXSIDEAREACAR 1407.62 LAYER M7 ;
    ANTENNAMAXCUTCAR 3.81326 LAYER VIA7 ;
  END tile_num[0]
  PIN sram_rdata_a0[31] 
    ANTENNAPARTIALMETALAREA 0.049 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2596 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0498 LAYER M4 ; 
    ANTENNAMAXAREACAR 35.241 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 151.639 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.00402 LAYER VIA4 ;
  END sram_rdata_a0[31]
  PIN sram_rdata_a0[30] 
    ANTENNAPARTIALMETALAREA 2.747 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.0868 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0246 LAYER M4 ; 
    ANTENNAMAXAREACAR 133.646 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 583.358 LAYER M4 ;
    ANTENNAMAXCUTCAR 2.43902 LAYER VIA4 ;
  END sram_rdata_a0[30]
  PIN sram_rdata_a0[29] 
    ANTENNAPARTIALMETALAREA 2.297 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 10.1068 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0246 LAYER M4 ; 
    ANTENNAMAXAREACAR 120.394 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 527.911 LAYER M4 ;
    ANTENNAMAXCUTCAR 2.43902 LAYER VIA4 ;
  END sram_rdata_a0[29]
  PIN sram_rdata_a0[28] 
    ANTENNAPARTIALMETALAREA 2.334 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 10.2696 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0246 LAYER M4 ; 
    ANTENNAMAXAREACAR 121.898 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 534.528 LAYER M4 ;
    ANTENNAMAXCUTCAR 2.43902 LAYER VIA4 ;
  END sram_rdata_a0[28]
  PIN sram_rdata_a0[27] 
    ANTENNAPARTIALMETALAREA 2.777 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.2188 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0246 LAYER M4 ; 
    ANTENNAMAXAREACAR 127.549 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 556.528 LAYER M4 ;
    ANTENNAMAXCUTCAR 2.43902 LAYER VIA4 ;
  END sram_rdata_a0[27]
  PIN sram_rdata_a0[26] 
    ANTENNAPARTIALMETALAREA 0.074 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.3256 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0246 LAYER M4 ; 
    ANTENNAMAXAREACAR 130.841 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 571.537 LAYER M4 ;
    ANTENNAMAXCUTCAR 2.43902 LAYER VIA4 ;
  END sram_rdata_a0[26]
  PIN sram_rdata_a0[25] 
    ANTENNAPARTIALMETALAREA 2.78 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.1616 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0246 LAYER M4 ; 
    ANTENNAMAXAREACAR 132.711 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 579.244 LAYER M4 ;
    ANTENNAMAXCUTCAR 2.43902 LAYER VIA4 ;
  END sram_rdata_a0[25]
  PIN sram_rdata_a0[24] 
    ANTENNAPARTIALMETALAREA 4.394 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 19.3336 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0927 LAYER M4 ; 
    ANTENNAMAXAREACAR 82.1357 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 360.374 LAYER M4 ;
    ANTENNAMAXCUTCAR 2.1978 LAYER VIA4 ;
  END sram_rdata_a0[24]
  PIN sram_rdata_a0[23] 
    ANTENNAPARTIALMETALAREA 4.657 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 20.4908 LAYER M4 ;
    ANTENNAPARTIALCUTAREA 0.02 LAYER VIA4 ;
    ANTENNAPARTIALMETALAREA 3.586 LAYER M5 ;
    ANTENNAPARTIALMETALSIDEAREA 15.6112 LAYER M5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1092 LAYER M5 ; 
    ANTENNAMAXAREACAR 49.293 LAYER M5 ;
    ANTENNAMAXSIDEAREACAR 213.773 LAYER M5 ;
    ANTENNAMAXCUTCAR 2.1978 LAYER VIA5 ;
  END sram_rdata_a0[23]
  PIN sram_rdata_a0[22] 
    ANTENNAPARTIALMETALAREA 3.135 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.7676 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0273 LAYER M4 ; 
    ANTENNAMAXAREACAR 122.56 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 538.432 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.8315 LAYER VIA4 ;
  END sram_rdata_a0[22]
  PIN sram_rdata_a0[21] 
    ANTENNAPARTIALMETALAREA 2.697 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 11.8668 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M4 ; 
    ANTENNAMAXAREACAR 51.0866 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 223.763 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.657895 LAYER VIA4 ;
  END sram_rdata_a0[21]
  PIN sram_rdata_a0[20] 
    ANTENNAPARTIALMETALAREA 2.907 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.7908 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M4 ; 
    ANTENNAMAXAREACAR 45.7138 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 200.123 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.657895 LAYER VIA4 ;
  END sram_rdata_a0[20]
  PIN sram_rdata_a0[19] 
    ANTENNAPARTIALMETALAREA 2.917 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.8348 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M4 ; 
    ANTENNAMAXAREACAR 45.3849 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 198.675 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.657895 LAYER VIA4 ;
  END sram_rdata_a0[19]
  PIN sram_rdata_a0[18] 
    ANTENNAPARTIALMETALAREA 3.123 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.6708 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M4 ; 
    ANTENNAMAXAREACAR 41.3279 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 180.825 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.657895 LAYER VIA4 ;
  END sram_rdata_a0[18]
  PIN sram_rdata_a0[17] 
    ANTENNAPARTIALMETALAREA 3.133 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.7148 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M4 ; 
    ANTENNAMAXAREACAR 40.5603 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 177.447 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.657895 LAYER VIA4 ;
  END sram_rdata_a0[17]
  PIN sram_rdata_a0[16] 
    ANTENNAPARTIALMETALAREA 3.543 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 15.5188 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0921 LAYER M4 ; 
    ANTENNAMAXAREACAR 76.2777 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 335.028 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.71528 LAYER VIA4 ;
  END sram_rdata_a0[16]
  PIN sram_rdata_a0[15] 
    ANTENNAPARTIALMETALAREA 1.189 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 5.2756 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0273 LAYER M4 ; 
    ANTENNAMAXAREACAR 258.678 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 1137.35 LAYER M4 ;
    ANTENNAMAXCUTCAR 2.1978 LAYER VIA4 ;
  END sram_rdata_a0[15]
  PIN sram_rdata_a0[14] 
    ANTENNAPARTIALMETALAREA 3.785 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 16.698 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M4 ; 
    ANTENNAMAXAREACAR 45.4726 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 199.544 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.657895 LAYER VIA4 ;
  END sram_rdata_a0[14]
  PIN sram_rdata_a0[13] 
    ANTENNAPARTIALMETALAREA 2.097 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 9.2268 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M4 ; 
    ANTENNAMAXAREACAR 53.0603 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 232.447 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.657895 LAYER VIA4 ;
  END sram_rdata_a0[13]
  PIN sram_rdata_a0[12] 
    ANTENNAPARTIALMETALAREA 3.703 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 16.2228 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M4 ; 
    ANTENNAMAXAREACAR 47.2489 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 206.877 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.657895 LAYER VIA4 ;
  END sram_rdata_a0[12]
  PIN sram_rdata_a0[11] 
    ANTENNAPARTIALMETALAREA 3.777 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 16.6188 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M4 ; 
    ANTENNAMAXAREACAR 47.7971 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 209.289 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.548246 LAYER VIA4 ;
  END sram_rdata_a0[11]
  PIN sram_rdata_a0[10] 
    ANTENNAPARTIALMETALAREA 3.907 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 17.1908 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M4 ; 
    ANTENNAMAXAREACAR 49.4419 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 216.526 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.657895 LAYER VIA4 ;
  END sram_rdata_a0[10]
  PIN sram_rdata_a0[9] 
    ANTENNAPARTIALMETALAREA 4.417 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 19.4348 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M4 ; 
    ANTENNAMAXAREACAR 54.1568 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 237.272 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.657895 LAYER VIA4 ;
  END sram_rdata_a0[9]
  PIN sram_rdata_a0[8] 
    ANTENNAPARTIALMETALAREA 4.239 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 18.6956 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0513 LAYER M4 ; 
    ANTENNAMAXAREACAR 104.455 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 456.357 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.88799 LAYER VIA4 ;
  END sram_rdata_a0[8]
  PIN sram_rdata_a0[7] 
    ANTENNAPARTIALMETALAREA 4.57 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 20.0112 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.12 LAYER M4 ; 
    ANTENNAMAXAREACAR 49.5049 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 216.659 LAYER M4 ;
    ANTENNAMAXCUTCAR 2.36447 LAYER VIA4 ;
  END sram_rdata_a0[7]
  PIN sram_rdata_a0[6] 
    ANTENNAPARTIALMETALAREA 2.447 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 10.7668 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M4 ; 
    ANTENNAMAXAREACAR 57.5559 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 252.228 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.657895 LAYER VIA4 ;
  END sram_rdata_a0[6]
  PIN sram_rdata_a0[5] 
    ANTENNAPARTIALMETALAREA 2.637 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 11.6028 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M4 ; 
    ANTENNAMAXAREACAR 51.1305 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 223.956 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.548246 LAYER VIA4 ;
  END sram_rdata_a0[5]
  PIN sram_rdata_a0[4] 
    ANTENNAPARTIALMETALAREA 2.947 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.9668 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M4 ; 
    ANTENNAMAXAREACAR 45.2752 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 198.193 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.657895 LAYER VIA4 ;
  END sram_rdata_a0[4]
  PIN sram_rdata_a0[3] 
    ANTENNAPARTIALMETALAREA 3.137 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.8028 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M4 ; 
    ANTENNAMAXAREACAR 46.2621 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 202.535 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.657895 LAYER VIA4 ;
  END sram_rdata_a0[3]
  PIN sram_rdata_a0[2] 
    ANTENNAPARTIALMETALAREA 3.267 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 14.3748 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M4 ; 
    ANTENNAMAXAREACAR 47.0296 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 205.912 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.657895 LAYER VIA4 ;
  END sram_rdata_a0[2]
  PIN sram_rdata_a0[1] 
    ANTENNAPARTIALMETALAREA 3.517 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 15.4748 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M4 ; 
    ANTENNAMAXAREACAR 49.5515 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 217.009 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.657895 LAYER VIA4 ;
  END sram_rdata_a0[1]
  PIN sram_rdata_a0[0] 
    ANTENNAPARTIALMETALAREA 2.839 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.5356 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0813 LAYER M4 ; 
    ANTENNAMAXAREACAR 112.658 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 496.168 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.74413 LAYER VIA4 ;
  END sram_rdata_a0[0]
  PIN sram_rdata_a1[31] 
    ANTENNAPARTIALMETALAREA 5.283 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 23.2628 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1092 LAYER M4 ; 
    ANTENNAMAXAREACAR 78.0037 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 341.916 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.0989 LAYER VIA4 ;
  END sram_rdata_a1[31]
  PIN sram_rdata_a1[30] 
    ANTENNAPARTIALMETALAREA 3.275 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 14.3836 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0246 LAYER M4 ; 
    ANTENNAMAXAREACAR 161.179 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 709.057 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.62602 LAYER VIA4 ;
  END sram_rdata_a1[30]
  PIN sram_rdata_a1[29] 
    ANTENNAPARTIALMETALAREA 2.907 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.8788 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0246 LAYER M4 ; 
    ANTENNAMAXAREACAR 167.846 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 737.317 LAYER M4 ;
    ANTENNAMAXCUTCAR 2.03252 LAYER VIA4 ;
  END sram_rdata_a1[29]
  PIN sram_rdata_a1[28] 
    ANTENNAPARTIALMETALAREA 3.063 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.4068 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M4 ; 
    ANTENNAMAXAREACAR 41.7664 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 182.754 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.657895 LAYER VIA4 ;
  END sram_rdata_a1[28]
  PIN sram_rdata_a1[27] 
    ANTENNAPARTIALMETALAREA 3.809 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 16.8036 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0246 LAYER M4 ; 
    ANTENNAMAXAREACAR 178.496 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 782.39 LAYER M4 ;
    ANTENNAMAXCUTCAR 2.03252 LAYER VIA4 ;
  END sram_rdata_a1[27]
  PIN sram_rdata_a1[26] 
    ANTENNAPARTIALMETALAREA 2.583 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 11.2948 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M4 ; 
    ANTENNAMAXAREACAR 36.0428 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 157.57 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.657895 LAYER VIA4 ;
  END sram_rdata_a1[26]
  PIN sram_rdata_a1[25] 
    ANTENNAPARTIALMETALAREA 0.017 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0748 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M4 ; 
    ANTENNAMAXAREACAR 44.5077 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 194.816 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.657895 LAYER VIA4 ;
  END sram_rdata_a1[25]
  PIN sram_rdata_a1[24] 
    ANTENNAPARTIALMETALAREA 4.003 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 17.5428 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0921 LAYER M4 ; 
    ANTENNAMAXAREACAR 55.8868 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 242.633 LAYER M4 ;
    ANTENNAMAXCUTCAR 2.24719 LAYER VIA4 ;
  END sram_rdata_a1[24]
  PIN sram_rdata_a1[23] 
    ANTENNAPARTIALMETALAREA 4.893 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 21.4588 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1473 LAYER M4 ; 
    ANTENNAMAXAREACAR 45.7336 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 199.627 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.08413 LAYER VIA4 ;
  END sram_rdata_a1[23]
  PIN sram_rdata_a1[22] 
    ANTENNAPARTIALMETALAREA 3.589 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 15.8356 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M4 ; 
    ANTENNAMAXAREACAR 57.1393 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 250.877 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.657895 LAYER VIA4 ;
  END sram_rdata_a1[22]
  PIN sram_rdata_a1[21] 
    ANTENNAPARTIALMETALAREA 2.617 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 11.5148 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M4 ; 
    ANTENNAMAXAREACAR 58.5428 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 256.57 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.657895 LAYER VIA4 ;
  END sram_rdata_a1[21]
  PIN sram_rdata_a1[20] 
    ANTENNAPARTIALMETALAREA 3.387 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 14.9028 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M4 ; 
    ANTENNAMAXAREACAR 52.9507 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 231.965 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.657895 LAYER VIA4 ;
  END sram_rdata_a1[20]
  PIN sram_rdata_a1[19] 
    ANTENNAPARTIALMETALAREA 3.557 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 15.6508 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M4 ; 
    ANTENNAMAXAREACAR 48.455 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 212.184 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.657895 LAYER VIA4 ;
  END sram_rdata_a1[19]
  PIN sram_rdata_a1[18] 
    ANTENNAPARTIALMETALAREA 1.827 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 8.0388 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M4 ; 
    ANTENNAMAXAREACAR 45.4945 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 199.158 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.657895 LAYER VIA4 ;
  END sram_rdata_a1[18]
  PIN sram_rdata_a1[17] 
    ANTENNAPARTIALMETALAREA 3.157 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.8908 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M4 ; 
    ANTENNAMAXAREACAR 38.148 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 166.833 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.657895 LAYER VIA4 ;
  END sram_rdata_a1[17]
  PIN sram_rdata_a1[16] 
    ANTENNAPARTIALMETALAREA 2.839 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.5356 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0246 LAYER M4 ; 
    ANTENNAMAXAREACAR 142.317 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 623.203 LAYER M4 ;
    ANTENNAMAXCUTCAR 2.03252 LAYER VIA4 ;
  END sram_rdata_a1[16]
  PIN sram_rdata_a1[15] 
    ANTENNAPARTIALMETALAREA 5.517 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 24.2748 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.12 LAYER M4 ; 
    ANTENNAMAXAREACAR 57.6646 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 253.308 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.63187 LAYER VIA4 ;
  END sram_rdata_a1[15]
  PIN sram_rdata_a1[14] 
    ANTENNAPARTIALMETALAREA 5.267 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 23.1748 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M4 ; 
    ANTENNAMAXAREACAR 64.5735 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 283.105 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.657895 LAYER VIA4 ;
  END sram_rdata_a1[14]
  PIN sram_rdata_a1[13] 
    ANTENNAPARTIALMETALAREA 4.977 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 21.8988 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M4 ; 
    ANTENNAMAXAREACAR 61.1743 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 268.149 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.657895 LAYER VIA4 ;
  END sram_rdata_a1[13]
  PIN sram_rdata_a1[12] 
    ANTENNAPARTIALMETALAREA 4.947 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 21.7668 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M4 ; 
    ANTENNAMAXAREACAR 59.3103 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 259.947 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.657895 LAYER VIA4 ;
  END sram_rdata_a1[12]
  PIN sram_rdata_a1[11] 
    ANTENNAPARTIALMETALAREA 4.797 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 21.1068 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M4 ; 
    ANTENNAMAXAREACAR 59.2007 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 259.465 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.657895 LAYER VIA4 ;
  END sram_rdata_a1[11]
  PIN sram_rdata_a1[10] 
    ANTENNAPARTIALMETALAREA 4.825 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 21.274 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M4 ; 
    ANTENNAMAXAREACAR 56.8761 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 249.719 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.657895 LAYER VIA4 ;
  END sram_rdata_a1[10]
  PIN sram_rdata_a1[9] 
    ANTENNAPARTIALMETALAREA 4.697 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 20.6668 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M4 ; 
    ANTENNAMAXAREACAR 54.5954 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 239.202 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.657895 LAYER VIA4 ;
  END sram_rdata_a1[9]
  PIN sram_rdata_a1[8] 
    ANTENNAPARTIALMETALAREA 4.819 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 21.2476 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0813 LAYER M4 ; 
    ANTENNAMAXAREACAR 78.0789 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 342.343 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.74413 LAYER VIA4 ;
  END sram_rdata_a1[8]
  PIN sram_rdata_a1[7] 
    ANTENNAPARTIALMETALAREA 5.037 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 22.1628 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.12 LAYER M4 ; 
    ANTENNAMAXAREACAR 55.6772 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 243.599 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.06593 LAYER VIA4 ;
  END sram_rdata_a1[7]
  PIN sram_rdata_a1[6] 
    ANTENNAPARTIALMETALAREA 5.527 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 24.3188 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M4 ; 
    ANTENNAMAXAREACAR 63.1261 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 276.737 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.548246 LAYER VIA4 ;
  END sram_rdata_a1[6]
  PIN sram_rdata_a1[5] 
    ANTENNAPARTIALMETALAREA 3.857 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 16.9708 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M4 ; 
    ANTENNAMAXAREACAR 62.4901 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 273.939 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.657895 LAYER VIA4 ;
  END sram_rdata_a1[5]
  PIN sram_rdata_a1[4] 
    ANTENNAPARTIALMETALAREA 4.867 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 21.4148 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M4 ; 
    ANTENNAMAXAREACAR 60.1875 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 263.807 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.657895 LAYER VIA4 ;
  END sram_rdata_a1[4]
  PIN sram_rdata_a1[3] 
    ANTENNAPARTIALMETALAREA 4.957 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 21.8108 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M4 ; 
    ANTENNAMAXAREACAR 58.1042 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 254.64 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.657895 LAYER VIA4 ;
  END sram_rdata_a1[3]
  PIN sram_rdata_a1[2] 
    ANTENNAPARTIALMETALAREA 4.163 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 18.2468 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M4 ; 
    ANTENNAMAXAREACAR 53.3235 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 233.605 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.657895 LAYER VIA4 ;
  END sram_rdata_a1[2]
  PIN sram_rdata_a1[1] 
    ANTENNAPARTIALMETALAREA 4.455 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 19.646 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M4 ; 
    ANTENNAMAXAREACAR 53.0384 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 232.833 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.657895 LAYER VIA4 ;
  END sram_rdata_a1[1]
  PIN sram_rdata_a1[0] 
    ANTENNAPARTIALMETALAREA 4.355 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 19.1356 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0513 LAYER M4 ; 
    ANTENNAMAXAREACAR 109.701 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 480.811 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.88799 LAYER VIA4 ;
  END sram_rdata_a1[0]
  PIN sram_rdata_b0[31] 
    ANTENNAPARTIALMETALAREA 4.777 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 21.0188 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0819 LAYER M4 ; 
    ANTENNAMAXAREACAR 71.8584 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 312.889 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.221 LAYER VIA4 ;
  END sram_rdata_b0[31]
  PIN sram_rdata_b0[30] 
    ANTENNAPARTIALMETALAREA 2.827 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.4388 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0246 LAYER M4 ; 
    ANTENNAMAXAREACAR 125.679 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 548.821 LAYER M4 ;
    ANTENNAMAXCUTCAR 2.43902 LAYER VIA4 ;
  END sram_rdata_b0[30]
  PIN sram_rdata_b0[29] 
    ANTENNAPARTIALMETALAREA 2.857 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.5708 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0246 LAYER M4 ; 
    ANTENNAMAXAREACAR 125.638 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 549.976 LAYER M4 ;
    ANTENNAMAXCUTCAR 2.43902 LAYER VIA4 ;
  END sram_rdata_b0[29]
  PIN sram_rdata_b0[28] 
    ANTENNAPARTIALMETALAREA 2.827 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.4388 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0246 LAYER M4 ; 
    ANTENNAMAXAREACAR 121.533 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 533.439 LAYER M4 ;
    ANTENNAMAXCUTCAR 2.43902 LAYER VIA4 ;
  END sram_rdata_b0[28]
  PIN sram_rdata_b0[27] 
    ANTENNAPARTIALMETALAREA 2.973 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.0108 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0246 LAYER M4 ; 
    ANTENNAMAXAREACAR 128.28 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 560.268 LAYER M4 ;
    ANTENNAMAXCUTCAR 2.43902 LAYER VIA4 ;
  END sram_rdata_b0[27]
  PIN sram_rdata_b0[26] 
    ANTENNAPARTIALMETALAREA 2.827 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.4388 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0246 LAYER M4 ; 
    ANTENNAMAXAREACAR 139.5 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 609.634 LAYER M4 ;
    ANTENNAMAXCUTCAR 2.43902 LAYER VIA4 ;
  END sram_rdata_b0[26]
  PIN sram_rdata_b0[25] 
    ANTENNAPARTIALMETALAREA 2.613 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 11.4268 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0246 LAYER M4 ; 
    ANTENNAMAXAREACAR 122.589 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 535.228 LAYER M4 ;
    ANTENNAMAXCUTCAR 2.43902 LAYER VIA4 ;
  END sram_rdata_b0[25]
  PIN sram_rdata_b0[24] 
    ANTENNAPARTIALMETALAREA 3.319 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 14.6476 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0819 LAYER M4 ; 
    ANTENNAMAXAREACAR 62.9805 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 276.383 LAYER M4 ;
    ANTENNAMAXCUTCAR 2.442 LAYER VIA4 ;
  END sram_rdata_b0[24]
  PIN sram_rdata_b0[23] 
    ANTENNAPARTIALMETALAREA 0.049 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2596 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0498 LAYER M4 ; 
    ANTENNAMAXAREACAR 72.9116 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 319.333 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.00402 LAYER VIA4 ;
  END sram_rdata_b0[23]
  PIN sram_rdata_b0[22] 
    ANTENNAPARTIALMETALAREA 0.263 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.2012 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0498 LAYER M4 ; 
    ANTENNAMAXAREACAR 90.3414 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 395.494 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.00402 LAYER VIA4 ;
  END sram_rdata_b0[22]
  PIN sram_rdata_b0[21] 
    ANTENNAPARTIALMETALAREA 4.217 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 18.5548 LAYER M4 ;
    ANTENNAPARTIALCUTAREA 0.02 LAYER VIA4 ;
    ANTENNAPARTIALMETALAREA 6.25 LAYER M5 ;
    ANTENNAPARTIALMETALSIDEAREA 27.4032 LAYER M5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M5 ; 
    ANTENNAMAXAREACAR 76.3607 LAYER M5 ;
    ANTENNAMAXSIDEAREACAR 334.39 LAYER M5 ;
    ANTENNAMAXCUTCAR 0.877193 LAYER VIA5 ;
  END sram_rdata_b0[21]
  PIN sram_rdata_b0[20] 
    ANTENNAPARTIALMETALAREA 3.525 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 15.554 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M4 ; 
    ANTENNAMAXAREACAR 45.4726 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 199.544 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.657895 LAYER VIA4 ;
  END sram_rdata_b0[20]
  PIN sram_rdata_b0[19] 
    ANTENNAPARTIALMETALAREA 3.375 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 14.894 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M4 ; 
    ANTENNAMAXAREACAR 50.1217 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 220 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.657895 LAYER VIA4 ;
  END sram_rdata_b0[19]
  PIN sram_rdata_b0[18] 
    ANTENNAPARTIALMETALAREA 2.507 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 11.0308 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M4 ; 
    ANTENNAMAXAREACAR 104.047 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 456.789 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.657895 LAYER VIA4 ;
  END sram_rdata_b0[18]
  PIN sram_rdata_b0[17] 
    ANTENNAPARTIALMETALAREA 2.589 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 11.4356 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0498 LAYER M4 ; 
    ANTENNAMAXAREACAR 84.5582 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 370.578 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.00402 LAYER VIA4 ;
  END sram_rdata_b0[17]
  PIN sram_rdata_b0[16] 
    ANTENNAPARTIALMETALAREA 1.239 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 5.4956 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0273 LAYER M4 ; 
    ANTENNAMAXAREACAR 157.945 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 694.125 LAYER M4 ;
    ANTENNAMAXCUTCAR 2.1978 LAYER VIA4 ;
  END sram_rdata_b0[16]
  PIN sram_rdata_b0[15] 
    ANTENNAPARTIALMETALAREA 1.857 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 8.1708 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.12 LAYER M4 ; 
    ANTENNAMAXAREACAR 73.1332 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 319.439 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.63187 LAYER VIA4 ;
  END sram_rdata_b0[15]
  PIN sram_rdata_b0[14] 
    ANTENNAPARTIALMETALAREA 4.069 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 17.9476 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M4 ; 
    ANTENNAMAXAREACAR 58.455 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 256.667 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.657895 LAYER VIA4 ;
  END sram_rdata_b0[14]
  PIN sram_rdata_b0[13] 
    ANTENNAPARTIALMETALAREA 3.857 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 16.9708 LAYER M4 ;
    ANTENNAPARTIALCUTAREA 0.02 LAYER VIA4 ;
    ANTENNAPARTIALMETALAREA 6.59 LAYER M5 ;
    ANTENNAPARTIALMETALSIDEAREA 28.8992 LAYER M5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M5 ; 
    ANTENNAMAXAREACAR 86.7336 LAYER M5 ;
    ANTENNAMAXSIDEAREACAR 380.031 LAYER M5 ;
    ANTENNAMAXCUTCAR 0.877193 LAYER VIA5 ;
  END sram_rdata_b0[13]
  PIN sram_rdata_b0[12] 
    ANTENNAPARTIALMETALAREA 4.056 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 17.8904 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M4 ; 
    ANTENNAMAXAREACAR 49.3213 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 216.478 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.657895 LAYER VIA4 ;
  END sram_rdata_b0[12]
  PIN sram_rdata_b0[11] 
    ANTENNAPARTIALMETALAREA 3.691 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 16.214 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M4 ; 
    ANTENNAMAXAREACAR 54.5735 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 239.588 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.657895 LAYER VIA4 ;
  END sram_rdata_b0[11]
  PIN sram_rdata_b0[10] 
    ANTENNAPARTIALMETALAREA 3.201 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 14.058 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M4 ; 
    ANTENNAMAXAREACAR 38.0164 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 166.737 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.657895 LAYER VIA4 ;
  END sram_rdata_b0[10]
  PIN sram_rdata_b0[9] 
    ANTENNAPARTIALMETALAREA 2.597 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 11.4268 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M4 ; 
    ANTENNAMAXAREACAR 101.087 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 443.763 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.657895 LAYER VIA4 ;
  END sram_rdata_b0[9]
  PIN sram_rdata_b0[8] 
    ANTENNAPARTIALMETALAREA 0.943 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 4.1932 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0765 LAYER M4 ; 
    ANTENNAMAXAREACAR 145.742 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 641.004 LAYER M4 ;
    ANTENNAMAXCUTCAR 2.50863 LAYER VIA4 ;
  END sram_rdata_b0[8]
  PIN sram_rdata_b0[7] 
    ANTENNAPARTIALMETALAREA 3.129 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.8116 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0498 LAYER M4 ; 
    ANTENNAMAXAREACAR 79.739 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 349.373 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.00402 LAYER VIA4 ;
  END sram_rdata_b0[7]
  PIN sram_rdata_b0[6] 
    ANTENNAPARTIALMETALAREA 2.307 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 10.1508 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M4 ; 
    ANTENNAMAXAREACAR 120.714 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 530.123 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.657895 LAYER VIA4 ;
  END sram_rdata_b0[6]
  PIN sram_rdata_b0[5] 
    ANTENNAPARTIALMETALAREA 2.097 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 9.2268 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M4 ; 
    ANTENNAMAXAREACAR 118.192 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 519.026 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.657895 LAYER VIA4 ;
  END sram_rdata_b0[5]
  PIN sram_rdata_b0[4] 
    ANTENNAPARTIALMETALAREA 2.467 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 10.8548 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M4 ; 
    ANTENNAMAXAREACAR 111.942 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 491.526 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.657895 LAYER VIA4 ;
  END sram_rdata_b0[4]
  PIN sram_rdata_b0[3] 
    ANTENNAPARTIALMETALAREA 3.337 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 14.6828 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M4 ; 
    ANTENNAMAXAREACAR 50.4287 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 220.868 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.657895 LAYER VIA4 ;
  END sram_rdata_b0[3]
  PIN sram_rdata_b0[2] 
    ANTENNAPARTIALMETALAREA 1.887 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 8.3028 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M4 ; 
    ANTENNAMAXAREACAR 52.7314 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 231 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.657895 LAYER VIA4 ;
  END sram_rdata_b0[2]
  PIN sram_rdata_b0[1] 
    ANTENNAPARTIALMETALAREA 2.377 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 10.4588 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M4 ; 
    ANTENNAMAXAREACAR 50.2094 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 219.904 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.657895 LAYER VIA4 ;
  END sram_rdata_b0[1]
  PIN sram_rdata_b0[0] 
    ANTENNAPARTIALMETALAREA 4.337 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 19.1708 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0273 LAYER M4 ; 
    ANTENNAMAXAREACAR 164.612 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 727.648 LAYER M4 ;
    ANTENNAMAXCUTCAR 2.1978 LAYER VIA4 ;
  END sram_rdata_b0[0]
  PIN sram_rdata_b1[31] 
    ANTENNAPARTIALMETALAREA 2.337 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 10.2828 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.12 LAYER M4 ; 
    ANTENNAMAXAREACAR 68.9516 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 302.225 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.63187 LAYER VIA4 ;
  END sram_rdata_b1[31]
  PIN sram_rdata_b1[30] 
    ANTENNAPARTIALMETALAREA 2.267 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 9.9748 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M4 ; 
    ANTENNAMAXAREACAR 68.0822 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 298.544 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.657895 LAYER VIA4 ;
  END sram_rdata_b1[30]
  PIN sram_rdata_b1[29] 
    ANTENNAPARTIALMETALAREA 2.137 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 9.4028 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M4 ; 
    ANTENNAMAXAREACAR 65.5603 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 287.447 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.657895 LAYER VIA4 ;
  END sram_rdata_b1[29]
  PIN sram_rdata_b1[28] 
    ANTENNAPARTIALMETALAREA 2.227 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 9.7988 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M4 ; 
    ANTENNAMAXAREACAR 61.7226 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 270.561 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.657895 LAYER VIA4 ;
  END sram_rdata_b1[28]
  PIN sram_rdata_b1[27] 
    ANTENNAPARTIALMETALAREA 3.037 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.3628 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M4 ; 
    ANTENNAMAXAREACAR 55.4726 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 243.061 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.657895 LAYER VIA4 ;
  END sram_rdata_b1[27]
  PIN sram_rdata_b1[26] 
    ANTENNAPARTIALMETALAREA 2.823 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.3508 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M4 ; 
    ANTENNAMAXAREACAR 49.6612 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 217.491 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.657895 LAYER VIA4 ;
  END sram_rdata_b1[26]
  PIN sram_rdata_b1[25] 
    ANTENNAPARTIALMETALAREA 2.733 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 11.9548 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M4 ; 
    ANTENNAMAXAREACAR 43.1919 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 189.026 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.657895 LAYER VIA4 ;
  END sram_rdata_b1[25]
  PIN sram_rdata_b1[24] 
    ANTENNAPARTIALMETALAREA 1.943 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 8.4788 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0921 LAYER M4 ; 
    ANTENNAMAXAREACAR 49.1828 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 215.304 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.18337 LAYER VIA4 ;
  END sram_rdata_b1[24]
  PIN sram_rdata_b1[23] 
    ANTENNAPARTIALMETALAREA 3.657 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 16.0908 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.12 LAYER M4 ; 
    ANTENNAMAXAREACAR 60.0092 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 262.397 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.26557 LAYER VIA4 ;
  END sram_rdata_b1[23]
  PIN sram_rdata_b1[22] 
    ANTENNAPARTIALMETALAREA 1.827 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 8.0388 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M4 ; 
    ANTENNAMAXAREACAR 52.9507 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 231.965 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.657895 LAYER VIA4 ;
  END sram_rdata_b1[22]
  PIN sram_rdata_b1[21] 
    ANTENNAPARTIALMETALAREA 3.593 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 15.7388 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M4 ; 
    ANTENNAMAXAREACAR 46.3059 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 202.728 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.657895 LAYER VIA4 ;
  END sram_rdata_b1[21]
  PIN sram_rdata_b1[20] 
    ANTENNAPARTIALMETALAREA 3.347 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 14.7268 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M4 ; 
    ANTENNAMAXAREACAR 41.7664 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 182.754 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.657895 LAYER VIA4 ;
  END sram_rdata_b1[20]
  PIN sram_rdata_b1[19] 
    ANTENNAPARTIALMETALAREA 3.037 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.3628 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M4 ; 
    ANTENNAMAXAREACAR 39.9024 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 174.553 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.657895 LAYER VIA4 ;
  END sram_rdata_b1[19]
  PIN sram_rdata_b1[18] 
    ANTENNAPARTIALMETALAREA 3.147 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.8468 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M4 ; 
    ANTENNAMAXAREACAR 37.8191 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 165.386 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.657895 LAYER VIA4 ;
  END sram_rdata_b1[18]
  PIN sram_rdata_b1[17] 
    ANTENNAPARTIALMETALAREA 2.897 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.7468 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M4 ; 
    ANTENNAMAXAREACAR 35.2971 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 154.289 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.657895 LAYER VIA4 ;
  END sram_rdata_b1[17]
  PIN sram_rdata_b1[16] 
    ANTENNAPARTIALMETALAREA 1.863 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 8.1268 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.093 LAYER M4 ; 
    ANTENNAMAXAREACAR 46.0991 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 201.741 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.17917 LAYER VIA4 ;
  END sram_rdata_b1[16]
  PIN sram_rdata_b1[15] 
    ANTENNAPARTIALMETALAREA 4.137 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 18.2028 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1473 LAYER M4 ; 
    ANTENNAMAXAREACAR 41.594 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 182.157 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.60098 LAYER VIA4 ;
  END sram_rdata_b1[15]
  PIN sram_rdata_b1[14] 
    ANTENNAPARTIALMETALAREA 3.587 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 15.7828 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M4 ; 
    ANTENNAMAXAREACAR 42.8629 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 187.579 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.657895 LAYER VIA4 ;
  END sram_rdata_b1[14]
  PIN sram_rdata_b1[13] 
    ANTENNAPARTIALMETALAREA 3.773 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 16.5308 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M4 ; 
    ANTENNAMAXAREACAR 44.6612 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 195.491 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.657895 LAYER VIA4 ;
  END sram_rdata_b1[13]
  PIN sram_rdata_b1[12] 
    ANTENNAPARTIALMETALAREA 3.047 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.4068 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M4 ; 
    ANTENNAMAXAREACAR 42.8629 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 187.579 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.657895 LAYER VIA4 ;
  END sram_rdata_b1[12]
  PIN sram_rdata_b1[11] 
    ANTENNAPARTIALMETALAREA 3.253 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 14.2428 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M4 ; 
    ANTENNAMAXAREACAR 39.1787 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 171.368 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.657895 LAYER VIA4 ;
  END sram_rdata_b1[11]
  PIN sram_rdata_b1[10] 
    ANTENNAPARTIALMETALAREA 3.147 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.8468 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M4 ; 
    ANTENNAMAXAREACAR 36.9419 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 161.526 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.657895 LAYER VIA4 ;
  END sram_rdata_b1[10]
  PIN sram_rdata_b1[9] 
    ANTENNAPARTIALMETALAREA 2.937 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.9228 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M4 ; 
    ANTENNAMAXAREACAR 35.2971 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 154.289 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.657895 LAYER VIA4 ;
  END sram_rdata_b1[9]
  PIN sram_rdata_b1[8] 
    ANTENNAPARTIALMETALAREA 2.675 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 11.7436 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0813 LAYER M4 ; 
    ANTENNAMAXAREACAR 42.4608 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 186.733 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.24107 LAYER VIA4 ;
  END sram_rdata_b1[8]
  PIN sram_rdata_b1[7] 
    ANTENNAPARTIALMETALAREA 1.829 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 8.0916 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0519 LAYER M4 ; 
    ANTENNAMAXAREACAR 82.2915 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 359.279 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.50331 LAYER VIA4 ;
  END sram_rdata_b1[7]
  PIN sram_rdata_b1[6] 
    ANTENNAPARTIALMETALAREA 1.827 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 8.0388 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M4 ; 
    ANTENNAMAXAREACAR 40.67 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 177.93 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.657895 LAYER VIA4 ;
  END sram_rdata_b1[6]
  PIN sram_rdata_b1[5] 
    ANTENNAPARTIALMETALAREA 3.177 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.9788 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M4 ; 
    ANTENNAMAXAREACAR 39.2445 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 171.658 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.657895 LAYER VIA4 ;
  END sram_rdata_b1[5]
  PIN sram_rdata_b1[4] 
    ANTENNAPARTIALMETALAREA 2.947 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.9668 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M4 ; 
    ANTENNAMAXAREACAR 36.7226 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 160.561 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.657895 LAYER VIA4 ;
  END sram_rdata_b1[4]
  PIN sram_rdata_b1[3] 
    ANTENNAPARTIALMETALAREA 2.337 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 10.2828 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M4 ; 
    ANTENNAMAXAREACAR 55.9112 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 244.991 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.657895 LAYER VIA4 ;
  END sram_rdata_b1[3]
  PIN sram_rdata_b1[2] 
    ANTENNAPARTIALMETALAREA 2.227 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 9.7988 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M4 ; 
    ANTENNAMAXAREACAR 53.6086 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 234.86 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.657895 LAYER VIA4 ;
  END sram_rdata_b1[2]
  PIN sram_rdata_b1[1] 
    ANTENNAPARTIALMETALAREA 1.957 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 8.6108 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0912 LAYER M4 ; 
    ANTENNAMAXAREACAR 46.0428 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 201.57 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.657895 LAYER VIA4 ;
  END sram_rdata_b1[1]
  PIN sram_rdata_b1[0] 
    ANTENNAPARTIALMETALAREA 2.439 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 10.7756 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0546 LAYER M4 ; 
    ANTENNAMAXAREACAR 96.6392 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 424.557 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.0989 LAYER VIA4 ;
  END sram_rdata_b1[0]
  PIN zero_point_a[7] 
    ANTENNAPARTIALMETALAREA 9.063 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 39.8948 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0966 LAYER M4 ; 
    ANTENNAMAXAREACAR 234.009 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 1022.8 LAYER M4 ;
    ANTENNAMAXCUTCAR 2.00803 LAYER VIA4 ;
  END zero_point_a[7]
  PIN zero_point_a[6] 
    ANTENNAPARTIALMETALAREA 0.0936 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.308 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0498 LAYER M4 ; 
    ANTENNAMAXAREACAR 61.8394 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 267.261 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.20482 LAYER VIA4 ;
  END zero_point_a[6]
  PIN zero_point_a[5] 
    ANTENNAPARTIALMETALAREA 0.0416 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0352 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1158 LAYER M4 ; 
    ANTENNAMAXAREACAR 69.0026 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 299.631 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.15843 LAYER VIA4 ;
  END zero_point_a[5]
  PIN zero_point_a[4] 
    ANTENNAPARTIALMETALAREA 0.0416 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0352 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1158 LAYER M4 ; 
    ANTENNAMAXAREACAR 324.308 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 1417.82 LAYER M4 ;
    ANTENNAMAXCUTCAR 2.61174 LAYER VIA4 ;
  END zero_point_a[4]
  PIN zero_point_a[3] 
    ANTENNAPARTIALMETALAREA 0.0416 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0352 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1158 LAYER M4 ; 
    ANTENNAMAXAREACAR 90.8852 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 396.751 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.15843 LAYER VIA4 ;
  END zero_point_a[3]
  PIN zero_point_a[2] 
    ANTENNAPARTIALMETALAREA 0.044 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1936 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1158 LAYER M4 ; 
    ANTENNAMAXAREACAR 236.255 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 1037.71 LAYER M4 ;
    ANTENNAMAXCUTCAR 2.61174 LAYER VIA4 ;
  END zero_point_a[2]
  PIN zero_point_a[1] 
    ANTENNAPARTIALMETALAREA 0.0416 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0352 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1158 LAYER M4 ; 
    ANTENNAMAXAREACAR 77.8568 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 338.906 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.15843 LAYER VIA4 ;
  END zero_point_a[1]
  PIN zero_point_a[0] 
    ANTENNAPARTIALMETALAREA 3.5116 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 15.3912 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0771 LAYER M4 ; 
    ANTENNAMAXAREACAR 140.675 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 613.546 LAYER M4 ;
    ANTENNAPARTIALCUTAREA 0.02 LAYER VIA4 ;
    ANTENNAMAXCUTCAR 2.45721 LAYER VIA4 ;
    ANTENNAPARTIALMETALAREA 1.93 LAYER M5 ;
    ANTENNAPARTIALMETALSIDEAREA 8.3952 LAYER M5 ;
    ANTENNAGATEAREA 0.1038 LAYER M5 ; 
    ANTENNAMAXAREACAR 159.268 LAYER M5 ;
    ANTENNAMAXSIDEAREACAR 694.425 LAYER M5 ;
    ANTENNAMAXCUTCAR 2.99625 LAYER VIA5 ;
  END zero_point_a[0]
  PIN zero_point_b[7] 
    ANTENNAPARTIALMETALAREA 0.0416 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0352 LAYER M4 ;
    ANTENNAPARTIALCUTAREA 0.02 LAYER VIA4 ;
    ANTENNAPARTIALMETALAREA 11.904 LAYER M5 ;
    ANTENNAPARTIALMETALSIDEAREA 52.2544 LAYER M5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1338 LAYER M5 ; 
    ANTENNAMAXAREACAR 276.777 LAYER M5 ;
    ANTENNAMAXSIDEAREACAR 1216.3 LAYER M5 ;
    ANTENNAMAXCUTCAR 2.13107 LAYER VIA5 ;
  END zero_point_b[7]
  PIN zero_point_b[6] 
    ANTENNAPARTIALMETALAREA 0.0416 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0352 LAYER M4 ;
    ANTENNAPARTIALCUTAREA 0.02 LAYER VIA4 ;
    ANTENNAPARTIALMETALAREA 1.394 LAYER M5 ;
    ANTENNAPARTIALMETALSIDEAREA 6.1072 LAYER M5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0273 LAYER M5 ; 
    ANTENNAMAXAREACAR 112.267 LAYER M5 ;
    ANTENNAMAXSIDEAREACAR 492.176 LAYER M5 ;
    ANTENNAMAXCUTCAR 2.9304 LAYER VIA5 ;
  END zero_point_b[6]
  PIN zero_point_b[5] 
    ANTENNAPARTIALMETALAREA 2.602 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 11.4928 LAYER M4 ;
    ANTENNAPARTIALCUTAREA 0.02 LAYER VIA4 ;
    ANTENNAPARTIALMETALAREA 7.53 LAYER M5 ;
    ANTENNAPARTIALMETALSIDEAREA 33.0352 LAYER M5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1158 LAYER M5 ; 
    ANTENNAMAXAREACAR 195.657 LAYER M5 ;
    ANTENNAMAXSIDEAREACAR 857.308 LAYER M5 ;
    ANTENNAMAXCUTCAR 1.33114 LAYER VIA5 ;
  END zero_point_b[5]
  PIN zero_point_b[4] 
    ANTENNAPARTIALMETALAREA 0.0936 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.308 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0498 LAYER M4 ; 
    ANTENNAMAXAREACAR 96.7791 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 422.795 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.00402 LAYER VIA4 ;
  END zero_point_b[4]
  PIN zero_point_b[3] 
    ANTENNAPARTIALMETALAREA 0.089 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.4356 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0498 LAYER M4 ; 
    ANTENNAMAXAREACAR 62.0683 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 269.823 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.20482 LAYER VIA4 ;
  END zero_point_b[3]
  PIN zero_point_b[2] 
    ANTENNAPARTIALMETALAREA 0.054 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2112 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0498 LAYER M4 ; 
    ANTENNAMAXAREACAR 59.8394 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 260.016 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.20482 LAYER VIA4 ;
  END zero_point_b[2]
  PIN zero_point_b[1] 
    ANTENNAPARTIALMETALAREA 0.0936 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.308 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0498 LAYER M4 ; 
    ANTENNAMAXAREACAR 62.6426 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 270.795 LAYER M4 ;
    ANTENNAMAXCUTCAR 1.20482 LAYER VIA4 ;
  END zero_point_b[1]
  PIN zero_point_b[0] 
    ANTENNAPARTIALMETALAREA 0.049 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2596 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0273 LAYER M4 ; 
    ANTENNAMAXAREACAR 109.227 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 479.766 LAYER M4 ;
    ANTENNAMAXCUTCAR 2.1978 LAYER VIA4 ;
  END zero_point_b[0]
  PIN sram_wdata_c[255] 
    ANTENNAPARTIALMETALAREA 1.937 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 8.5228 LAYER M4 ;
    ANTENNAPARTIALCUTAREA 0.02 LAYER VIA4 ;
    ANTENNADIFFAREA 1.092 LAYER M5 ; 
    ANTENNAPARTIALMETALAREA 0.17 LAYER M5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.6512 LAYER M5 ;
  END sram_wdata_c[255]
  PIN sram_wdata_c[254] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.134 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.7896 LAYER M4 ;
  END sram_wdata_c[254]
  PIN sram_wdata_c[253] 
    ANTENNAPARTIALMETALAREA 1.937 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 8.5228 LAYER M4 ;
    ANTENNAPARTIALCUTAREA 0.02 LAYER VIA4 ;
    ANTENNADIFFAREA 1.092 LAYER M5 ; 
    ANTENNAPARTIALMETALAREA 0.17 LAYER M5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.6512 LAYER M5 ;
  END sram_wdata_c[253]
  PIN sram_wdata_c[252] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.767 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.1748 LAYER M4 ;
  END sram_wdata_c[252]
  PIN sram_wdata_c[251] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.377 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 10.4588 LAYER M4 ;
  END sram_wdata_c[251]
  PIN sram_wdata_c[250] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.507 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 15.4308 LAYER M4 ;
  END sram_wdata_c[250]
  PIN sram_wdata_c[249] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.96 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.9536 LAYER M4 ;
  END sram_wdata_c[249]
  PIN sram_wdata_c[248] 
    ANTENNAPARTIALMETALAREA 1.991 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 8.7604 LAYER M4 ;
    ANTENNAPARTIALCUTAREA 0.02 LAYER VIA4 ;
    ANTENNADIFFAREA 1.092 LAYER M5 ; 
    ANTENNAPARTIALMETALAREA 0.17 LAYER M5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.6512 LAYER M5 ;
  END sram_wdata_c[248]
  PIN sram_wdata_c[247] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.377 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 14.8588 LAYER M4 ;
  END sram_wdata_c[247]
  PIN sram_wdata_c[246] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.047 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.4068 LAYER M4 ;
  END sram_wdata_c[246]
  PIN sram_wdata_c[245] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.037 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 8.9628 LAYER M4 ;
  END sram_wdata_c[245]
  PIN sram_wdata_c[244] 
    ANTENNAPARTIALMETALAREA 0.891 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.9204 LAYER M4 ;
    ANTENNAPARTIALCUTAREA 0.02 LAYER VIA4 ;
    ANTENNADIFFAREA 1.092 LAYER M5 ; 
    ANTENNAPARTIALMETALAREA 0.13 LAYER M5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.4752 LAYER M5 ;
  END sram_wdata_c[244]
  PIN sram_wdata_c[243] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.293 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 14.4188 LAYER M4 ;
  END sram_wdata_c[243]
  PIN sram_wdata_c[242] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.687 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 16.2228 LAYER M4 ;
  END sram_wdata_c[242]
  PIN sram_wdata_c[241] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.26 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 14.2736 LAYER M4 ;
  END sram_wdata_c[241]
  PIN sram_wdata_c[240] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.154 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.8776 LAYER M4 ;
  END sram_wdata_c[240]
  PIN sram_wdata_c[239] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 1.037 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 4.5628 LAYER M4 ;
  END sram_wdata_c[239]
  PIN sram_wdata_c[238] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.767 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.1748 LAYER M4 ;
  END sram_wdata_c[238]
  PIN sram_wdata_c[237] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.197 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 14.0668 LAYER M4 ;
  END sram_wdata_c[237]
  PIN sram_wdata_c[236] 
    ANTENNAPARTIALMETALAREA 0.017 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0748 LAYER M4 ;
    ANTENNAPARTIALCUTAREA 0.02 LAYER VIA4 ;
    ANTENNADIFFAREA 1.092 LAYER M5 ; 
    ANTENNAPARTIALMETALAREA 0.18 LAYER M5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.6952 LAYER M5 ;
  END sram_wdata_c[236]
  PIN sram_wdata_c[235] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.02 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.2176 LAYER M4 ;
  END sram_wdata_c[235]
  PIN sram_wdata_c[234] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.647 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 16.0468 LAYER M4 ;
  END sram_wdata_c[234]
  PIN sram_wdata_c[233] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.497 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 15.3868 LAYER M4 ;
  END sram_wdata_c[233]
  PIN sram_wdata_c[232] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.074 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2552 LAYER M4 ;
  END sram_wdata_c[232]
  PIN sram_wdata_c[231] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.157 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 9.4908 LAYER M4 ;
  END sram_wdata_c[231]
  PIN sram_wdata_c[230] 
    ANTENNADIFFAREA 0.9987 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.843 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.4388 LAYER M4 ;
  END sram_wdata_c[230]
  PIN sram_wdata_c[229] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.237 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 14.2428 LAYER M4 ;
  END sram_wdata_c[229]
  PIN sram_wdata_c[228] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.707 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 16.3108 LAYER M4 ;
  END sram_wdata_c[228]
  PIN sram_wdata_c[227] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.557 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 11.2508 LAYER M4 ;
  END sram_wdata_c[227]
  PIN sram_wdata_c[226] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.347 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 14.7268 LAYER M4 ;
  END sram_wdata_c[226]
  PIN sram_wdata_c[225] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.573 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 15.6508 LAYER M4 ;
  END sram_wdata_c[225]
  PIN sram_wdata_c[224] 
    ANTENNAPARTIALMETALAREA 2.014 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 8.8616 LAYER M4 ;
    ANTENNAPARTIALCUTAREA 0.02 LAYER VIA4 ;
    ANTENNADIFFAREA 1.092 LAYER M5 ; 
    ANTENNAPARTIALMETALAREA 0.33 LAYER M5 ;
    ANTENNAPARTIALMETALSIDEAREA 1.3552 LAYER M5 ;
  END sram_wdata_c[224]
  PIN sram_wdata_c[223] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.937 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 17.3228 LAYER M4 ;
  END sram_wdata_c[223]
  PIN sram_wdata_c[222] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.947 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.9668 LAYER M4 ;
  END sram_wdata_c[222]
  PIN sram_wdata_c[221] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 4.297 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 18.9068 LAYER M4 ;
  END sram_wdata_c[221]
  PIN sram_wdata_c[220] 
    ANTENNAPARTIALMETALAREA 1.931 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 8.4964 LAYER M4 ;
    ANTENNAPARTIALCUTAREA 0.02 LAYER VIA4 ;
    ANTENNADIFFAREA 1.092 LAYER M5 ; 
    ANTENNAPARTIALMETALAREA 0.35 LAYER M5 ;
    ANTENNAPARTIALMETALSIDEAREA 1.4432 LAYER M5 ;
  END sram_wdata_c[220]
  PIN sram_wdata_c[219] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.757 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.1308 LAYER M4 ;
  END sram_wdata_c[219]
  PIN sram_wdata_c[218] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 4.807 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 21.1508 LAYER M4 ;
  END sram_wdata_c[218]
  PIN sram_wdata_c[217] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 4.837 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 21.2828 LAYER M4 ;
  END sram_wdata_c[217]
  PIN sram_wdata_c[216] 
    ANTENNADIFFAREA 0.9987 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 4.267 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 18.7748 LAYER M4 ;
  END sram_wdata_c[216]
  PIN sram_wdata_c[215] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 4.097 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 18.0268 LAYER M4 ;
  END sram_wdata_c[215]
  PIN sram_wdata_c[214] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.987 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.1428 LAYER M4 ;
  END sram_wdata_c[214]
  PIN sram_wdata_c[213] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.637 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 16.0028 LAYER M4 ;
  END sram_wdata_c[213]
  PIN sram_wdata_c[212] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.827 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.4388 LAYER M4 ;
  END sram_wdata_c[212]
  PIN sram_wdata_c[211] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.177 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.7788 LAYER M4 ;
  END sram_wdata_c[211]
  PIN sram_wdata_c[210] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 5.047 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 22.2068 LAYER M4 ;
  END sram_wdata_c[210]
  PIN sram_wdata_c[209] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.851 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.518 LAYER M4 ;
  END sram_wdata_c[209]
  PIN sram_wdata_c[208] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 1.469 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 6.5076 LAYER M4 ;
  END sram_wdata_c[208]
  PIN sram_wdata_c[207] 
    ANTENNADIFFAREA 0.9987 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 4.053 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 17.7628 LAYER M4 ;
  END sram_wdata_c[207]
  PIN sram_wdata_c[206] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.147 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 9.4468 LAYER M4 ;
  END sram_wdata_c[206]
  PIN sram_wdata_c[205] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.797 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.3068 LAYER M4 ;
  END sram_wdata_c[205]
  PIN sram_wdata_c[204] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 1.987 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 8.6724 LAYER M4 ;
  END sram_wdata_c[204]
  PIN sram_wdata_c[203] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.077 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 9.1388 LAYER M4 ;
  END sram_wdata_c[203]
  PIN sram_wdata_c[202] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 1.091 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 4.8004 LAYER M4 ;
  END sram_wdata_c[202]
  PIN sram_wdata_c[201] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.997 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 4.3868 LAYER M4 ;
  END sram_wdata_c[201]
  PIN sram_wdata_c[200] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 1.311 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 5.7684 LAYER M4 ;
  END sram_wdata_c[200]
  PIN sram_wdata_c[199] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 1.977 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 8.6988 LAYER M4 ;
  END sram_wdata_c[199]
  PIN sram_wdata_c[198] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.841 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 16.874 LAYER M4 ;
  END sram_wdata_c[198]
  PIN sram_wdata_c[197] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.117 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 9.3148 LAYER M4 ;
  END sram_wdata_c[197]
  PIN sram_wdata_c[196] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.047 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 9.0068 LAYER M4 ;
  END sram_wdata_c[196]
  PIN sram_wdata_c[195] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.657 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 11.6908 LAYER M4 ;
  END sram_wdata_c[195]
  PIN sram_wdata_c[194] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.885 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 17.0676 LAYER M4 ;
  END sram_wdata_c[194]
  PIN sram_wdata_c[193] 
    ANTENNAPARTIALMETALAREA 1.897 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 8.3468 LAYER M4 ;
    ANTENNAPARTIALCUTAREA 0.02 LAYER VIA4 ;
    ANTENNAPARTIALMETALAREA 0.41 LAYER M5 ;
    ANTENNAPARTIALMETALSIDEAREA 1.7072 LAYER M5 ;
    ANTENNAPARTIALCUTAREA 0.02 LAYER VIA5 ;
    ANTENNADIFFAREA 1.092 LAYER M6 ; 
    ANTENNAPARTIALMETALAREA 3.158 LAYER M6 ;
    ANTENNAPARTIALMETALSIDEAREA 13.9392 LAYER M6 ;
  END sram_wdata_c[193]
  PIN sram_wdata_c[192] 
    ANTENNAPARTIALMETALAREA 1.991 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 8.7604 LAYER M4 ;
    ANTENNAPARTIALCUTAREA 0.02 LAYER VIA4 ;
    ANTENNAPARTIALMETALAREA 0.25 LAYER M5 ;
    ANTENNAPARTIALMETALSIDEAREA 1.0032 LAYER M5 ;
    ANTENNAPARTIALCUTAREA 0.02 LAYER VIA5 ;
    ANTENNADIFFAREA 1.092 LAYER M6 ; 
    ANTENNAPARTIALMETALAREA 3.398 LAYER M6 ;
    ANTENNAPARTIALMETALSIDEAREA 14.9952 LAYER M6 ;
  END sram_wdata_c[192]
  PIN sram_wdata_c[191] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.057 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2508 LAYER M4 ;
  END sram_wdata_c[191]
  PIN sram_wdata_c[190] 
    ANTENNAPARTIALMETALAREA 0.094 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.4136 LAYER M4 ;
    ANTENNAPARTIALCUTAREA 0.02 LAYER VIA4 ;
    ANTENNAPARTIALMETALAREA 11.77 LAYER M5 ;
    ANTENNAPARTIALMETALSIDEAREA 51.6912 LAYER M5 ;
    ANTENNAPARTIALCUTAREA 0.02 LAYER VIA5 ;
    ANTENNADIFFAREA 1.092 LAYER M6 ; 
    ANTENNAPARTIALMETALAREA 3.934 LAYER M6 ;
    ANTENNAPARTIALMETALSIDEAREA 17.2832 LAYER M6 ;
  END sram_wdata_c[190]
  PIN sram_wdata_c[189] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.057 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2508 LAYER M4 ;
  END sram_wdata_c[189]
  PIN sram_wdata_c[188] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.111 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.4884 LAYER M4 ;
  END sram_wdata_c[188]
  PIN sram_wdata_c[187] 
    ANTENNAPARTIALMETALAREA 0.157 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.6908 LAYER M4 ;
    ANTENNAPARTIALCUTAREA 0.02 LAYER VIA4 ;
    ANTENNADIFFAREA 1.092 LAYER M5 ; 
    ANTENNAPARTIALMETALAREA 12.01 LAYER M5 ;
    ANTENNAPARTIALMETALSIDEAREA 52.7472 LAYER M5 ;
  END sram_wdata_c[187]
  PIN sram_wdata_c[186] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.074 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2552 LAYER M4 ;
  END sram_wdata_c[186]
  PIN sram_wdata_c[185] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.531 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 15.51 LAYER M4 ;
  END sram_wdata_c[185]
  PIN sram_wdata_c[184] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.409 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 15.0436 LAYER M4 ;
  END sram_wdata_c[184]
  PIN sram_wdata_c[183] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 1.617 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 7.1148 LAYER M4 ;
  END sram_wdata_c[183]
  PIN sram_wdata_c[182] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 1.987 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 8.6724 LAYER M4 ;
  END sram_wdata_c[182]
  PIN sram_wdata_c[181] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 1.517 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 6.6748 LAYER M4 ;
  END sram_wdata_c[181]
  PIN sram_wdata_c[180] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 1.371 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 6.0324 LAYER M4 ;
  END sram_wdata_c[180]
  PIN sram_wdata_c[179] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 1.873 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 8.1708 LAYER M4 ;
  END sram_wdata_c[179]
  PIN sram_wdata_c[178] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.729 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.0516 LAYER M4 ;
  END sram_wdata_c[178]
  PIN sram_wdata_c[177] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 1.097 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 4.8268 LAYER M4 ;
  END sram_wdata_c[177]
  PIN sram_wdata_c[176] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 1.451 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 6.3844 LAYER M4 ;
  END sram_wdata_c[176]
  PIN sram_wdata_c[175] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.017 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0748 LAYER M4 ;
  END sram_wdata_c[175]
  PIN sram_wdata_c[174] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.191 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.8404 LAYER M4 ;
  END sram_wdata_c[174]
  PIN sram_wdata_c[173] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 4.531 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 19.91 LAYER M4 ;
  END sram_wdata_c[173]
  PIN sram_wdata_c[172] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 1.751 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 7.7044 LAYER M4 ;
  END sram_wdata_c[172]
  PIN sram_wdata_c[171] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 1.777 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 7.8188 LAYER M4 ;
  END sram_wdata_c[171]
  PIN sram_wdata_c[170] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 1.951 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 8.5844 LAYER M4 ;
  END sram_wdata_c[170]
  PIN sram_wdata_c[169] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 1.857 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 8.1708 LAYER M4 ;
  END sram_wdata_c[169]
  PIN sram_wdata_c[168] 
    ANTENNAPARTIALMETALAREA 3.547 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 15.6068 LAYER M4 ;
    ANTENNAPARTIALCUTAREA 0.02 LAYER VIA4 ;
    ANTENNADIFFAREA 1.092 LAYER M5 ; 
    ANTENNAPARTIALMETALAREA 1.39 LAYER M5 ;
    ANTENNAPARTIALMETALSIDEAREA 6.0192 LAYER M5 ;
  END sram_wdata_c[168]
  PIN sram_wdata_c[167] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.357 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 10.3708 LAYER M4 ;
  END sram_wdata_c[167]
  PIN sram_wdata_c[166] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.627 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 11.5588 LAYER M4 ;
  END sram_wdata_c[166]
  PIN sram_wdata_c[165] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.777 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 16.6188 LAYER M4 ;
  END sram_wdata_c[165]
  PIN sram_wdata_c[164] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.547 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 11.2068 LAYER M4 ;
  END sram_wdata_c[164]
  PIN sram_wdata_c[163] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.997 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 4.3868 LAYER M4 ;
  END sram_wdata_c[163]
  PIN sram_wdata_c[162] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.854 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.5576 LAYER M4 ;
  END sram_wdata_c[162]
  PIN sram_wdata_c[161] 
    ANTENNADIFFAREA 0.9987 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.097 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.6268 LAYER M4 ;
  END sram_wdata_c[161]
  PIN sram_wdata_c[160] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 4.167 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 18.3348 LAYER M4 ;
  END sram_wdata_c[160]
  PIN sram_wdata_c[159] 
    ANTENNADIFFAREA 0.9987 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.849 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.5796 LAYER M4 ;
  END sram_wdata_c[159]
  PIN sram_wdata_c[158] 
    ANTENNADIFFAREA 1.005 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 1.703 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 7.5372 LAYER M4 ;
  END sram_wdata_c[158]
  PIN sram_wdata_c[157] 
    ANTENNADIFFAREA 1.005 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 1.189 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 5.2756 LAYER M4 ;
  END sram_wdata_c[157]
  PIN sram_wdata_c[156] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 1.283 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 5.6892 LAYER M4 ;
  END sram_wdata_c[156]
  PIN sram_wdata_c[155] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 1.149 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 5.0996 LAYER M4 ;
  END sram_wdata_c[155]
  PIN sram_wdata_c[154] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 1.343 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 5.9532 LAYER M4 ;
  END sram_wdata_c[154]
  PIN sram_wdata_c[153] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 1.069 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 4.7476 LAYER M4 ;
  END sram_wdata_c[153]
  PIN sram_wdata_c[152] 
    ANTENNADIFFAREA 0.9987 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.819 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.4476 LAYER M4 ;
  END sram_wdata_c[152]
  PIN sram_wdata_c[151] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 1.449 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 6.4196 LAYER M4 ;
  END sram_wdata_c[151]
  PIN sram_wdata_c[150] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.503 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 2.2572 LAYER M4 ;
  END sram_wdata_c[150]
  PIN sram_wdata_c[149] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.189 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 9.6756 LAYER M4 ;
  END sram_wdata_c[149]
  PIN sram_wdata_c[148] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.423 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.9052 LAYER M4 ;
  END sram_wdata_c[148]
  PIN sram_wdata_c[147] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 1.589 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 7.0356 LAYER M4 ;
  END sram_wdata_c[147]
  PIN sram_wdata_c[146] 
    ANTENNADIFFAREA 0.9987 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.755 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.0956 LAYER M4 ;
  END sram_wdata_c[146]
  PIN sram_wdata_c[145] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 4.355 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 19.206 LAYER M4 ;
  END sram_wdata_c[145]
  PIN sram_wdata_c[144] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 4.761 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 21.0364 LAYER M4 ;
  END sram_wdata_c[144]
  PIN sram_wdata_c[143] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 4.283 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 18.8628 LAYER M4 ;
  END sram_wdata_c[143]
  PIN sram_wdata_c[142] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.855 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.5356 LAYER M4 ;
  END sram_wdata_c[142]
  PIN sram_wdata_c[141] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 4.747 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 20.9748 LAYER M4 ;
  END sram_wdata_c[141]
  PIN sram_wdata_c[140] 
    ANTENNAPARTIALMETALAREA 0.131 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.5764 LAYER M4 ;
    ANTENNAPARTIALCUTAREA 0.02 LAYER VIA4 ;
    ANTENNAPARTIALMETALAREA 13.39 LAYER M5 ;
    ANTENNAPARTIALMETALSIDEAREA 58.8192 LAYER M5 ;
    ANTENNAPARTIALCUTAREA 0.02 LAYER VIA5 ;
    ANTENNADIFFAREA 1.092 LAYER M6 ; 
    ANTENNAPARTIALMETALAREA 4.598 LAYER M6 ;
    ANTENNAPARTIALMETALSIDEAREA 20.2752 LAYER M6 ;
  END sram_wdata_c[140]
  PIN sram_wdata_c[139] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.769 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.2276 LAYER M4 ;
  END sram_wdata_c[139]
  PIN sram_wdata_c[138] 
    ANTENNAPARTIALMETALAREA 2.487 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 10.9428 LAYER M4 ;
    ANTENNAPARTIALCUTAREA 0.02 LAYER VIA4 ;
    ANTENNAPARTIALMETALAREA 10.01 LAYER M5 ;
    ANTENNAPARTIALMETALSIDEAREA 43.9472 LAYER M5 ;
    ANTENNAPARTIALCUTAREA 0.02 LAYER VIA5 ;
    ANTENNADIFFAREA 1.092 LAYER M6 ; 
    ANTENNAPARTIALMETALAREA 2.578 LAYER M6 ;
    ANTENNAPARTIALMETALSIDEAREA 11.3872 LAYER M6 ;
  END sram_wdata_c[138]
  PIN sram_wdata_c[137] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 4.587 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 20.2708 LAYER M4 ;
  END sram_wdata_c[137]
  PIN sram_wdata_c[136] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.283 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.2892 LAYER M4 ;
  END sram_wdata_c[136]
  PIN sram_wdata_c[135] 
    ANTENNAPARTIALCUTAREA 0.02 LAYER VIA4 ;
    ANTENNADIFFAREA 1.092 LAYER M5 ; 
    ANTENNAPARTIALMETALAREA 15.69 LAYER M5 ;
    ANTENNAPARTIALMETALSIDEAREA 68.9392 LAYER M5 ;
  END sram_wdata_c[135]
  PIN sram_wdata_c[134] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.063 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.3212 LAYER M4 ;
  END sram_wdata_c[134]
  PIN sram_wdata_c[133] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 1.829 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 8.0916 LAYER M4 ;
  END sram_wdata_c[133]
  PIN sram_wdata_c[132] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.139 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.6556 LAYER M4 ;
  END sram_wdata_c[132]
  PIN sram_wdata_c[131] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.865 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.5796 LAYER M4 ;
  END sram_wdata_c[131]
  PIN sram_wdata_c[130] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 4.201 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 18.5724 LAYER M4 ;
  END sram_wdata_c[130]
  PIN sram_wdata_c[129] 
    ANTENNAPARTIALMETALAREA 0.117 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.5148 LAYER M4 ;
    ANTENNAPARTIALCUTAREA 0.02 LAYER VIA4 ;
    ANTENNADIFFAREA 1.092 LAYER M5 ; 
    ANTENNAPARTIALMETALAREA 8.564 LAYER M5 ;
    ANTENNAPARTIALMETALSIDEAREA 37.5584 LAYER M5 ;
  END sram_wdata_c[129]
  PIN sram_wdata_c[128] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.855 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.5356 LAYER M4 ;
  END sram_wdata_c[128]
  PIN sram_wdata_c[127] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.537 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 11.1628 LAYER M4 ;
  END sram_wdata_c[127]
  PIN sram_wdata_c[126] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.687 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 11.8228 LAYER M4 ;
  END sram_wdata_c[126]
  PIN sram_wdata_c[125] 
    ANTENNADIFFAREA 0.6818 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.277 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 14.4188 LAYER M4 ;
  END sram_wdata_c[125]
  PIN sram_wdata_c[124] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.843 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.4388 LAYER M4 ;
  END sram_wdata_c[124]
  PIN sram_wdata_c[123] 
    ANTENNADIFFAREA 0.6818 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.357 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 14.7708 LAYER M4 ;
  END sram_wdata_c[123]
  PIN sram_wdata_c[122] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.767 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.1748 LAYER M4 ;
  END sram_wdata_c[122]
  PIN sram_wdata_c[121] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.377 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 10.4588 LAYER M4 ;
  END sram_wdata_c[121]
  PIN sram_wdata_c[120] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.963 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.9668 LAYER M4 ;
  END sram_wdata_c[120]
  PIN sram_wdata_c[119] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.833 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.3948 LAYER M4 ;
  END sram_wdata_c[119]
  PIN sram_wdata_c[118] 
    ANTENNADIFFAREA 0.9987 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 1.991 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 8.7604 LAYER M4 ;
  END sram_wdata_c[118]
  PIN sram_wdata_c[117] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.317 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 14.5948 LAYER M4 ;
  END sram_wdata_c[117]
  PIN sram_wdata_c[116] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.623 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 11.4708 LAYER M4 ;
  END sram_wdata_c[116]
  PIN sram_wdata_c[115] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.437 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.9228 LAYER M4 ;
  END sram_wdata_c[115]
  PIN sram_wdata_c[114] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.207 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 9.7108 LAYER M4 ;
  END sram_wdata_c[114]
  PIN sram_wdata_c[113] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.637 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 11.6028 LAYER M4 ;
  END sram_wdata_c[113]
  PIN sram_wdata_c[112] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 1.951 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 8.5844 LAYER M4 ;
  END sram_wdata_c[112]
  PIN sram_wdata_c[111] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 1.017 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 4.4748 LAYER M4 ;
  END sram_wdata_c[111]
  PIN sram_wdata_c[110] 
    ANTENNADIFFAREA 0.6818 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.823 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 16.7508 LAYER M4 ;
  END sram_wdata_c[110]
  PIN sram_wdata_c[109] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.497 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 10.9868 LAYER M4 ;
  END sram_wdata_c[109]
  PIN sram_wdata_c[108] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.327 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 10.2388 LAYER M4 ;
  END sram_wdata_c[108]
  PIN sram_wdata_c[107] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.257 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 9.9308 LAYER M4 ;
  END sram_wdata_c[107]
  PIN sram_wdata_c[106] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.127 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 9.3588 LAYER M4 ;
  END sram_wdata_c[106]
  PIN sram_wdata_c[105] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.935 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 17.358 LAYER M4 ;
  END sram_wdata_c[105]
  PIN sram_wdata_c[104] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.047 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 9.0068 LAYER M4 ;
  END sram_wdata_c[104]
  PIN sram_wdata_c[103] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.457 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 10.8108 LAYER M4 ;
  END sram_wdata_c[103]
  PIN sram_wdata_c[102] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.907 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.7908 LAYER M4 ;
  END sram_wdata_c[102]
  PIN sram_wdata_c[101] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.597 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 11.4268 LAYER M4 ;
  END sram_wdata_c[101]
  PIN sram_wdata_c[100] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.707 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 11.9108 LAYER M4 ;
  END sram_wdata_c[100]
  PIN sram_wdata_c[99] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.537 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 11.1628 LAYER M4 ;
  END sram_wdata_c[99]
  PIN sram_wdata_c[98] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 1.991 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 8.7604 LAYER M4 ;
  END sram_wdata_c[98]
  PIN sram_wdata_c[97] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.937 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.9228 LAYER M4 ;
  END sram_wdata_c[97]
  PIN sram_wdata_c[96] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.687 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 11.8228 LAYER M4 ;
  END sram_wdata_c[96]
  PIN sram_wdata_c[95] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.757 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.1308 LAYER M4 ;
  END sram_wdata_c[95]
  PIN sram_wdata_c[94] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.967 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.0548 LAYER M4 ;
  END sram_wdata_c[94]
  PIN sram_wdata_c[93] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.817 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.3948 LAYER M4 ;
  END sram_wdata_c[93]
  PIN sram_wdata_c[92] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.207 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 14.1108 LAYER M4 ;
  END sram_wdata_c[92]
  PIN sram_wdata_c[91] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 1.997 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 8.7868 LAYER M4 ;
  END sram_wdata_c[91]
  PIN sram_wdata_c[90] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 1.147 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 5.0468 LAYER M4 ;
  END sram_wdata_c[90]
  PIN sram_wdata_c[89] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.477 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 10.8988 LAYER M4 ;
  END sram_wdata_c[89]
  PIN sram_wdata_c[88] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.287 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 10.0628 LAYER M4 ;
  END sram_wdata_c[88]
  PIN sram_wdata_c[87] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.717 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 11.9548 LAYER M4 ;
  END sram_wdata_c[87]
  PIN sram_wdata_c[86] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.963 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.9668 LAYER M4 ;
  END sram_wdata_c[86]
  PIN sram_wdata_c[85] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.337 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 10.2828 LAYER M4 ;
  END sram_wdata_c[85]
  PIN sram_wdata_c[84] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.647 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 11.6468 LAYER M4 ;
  END sram_wdata_c[84]
  PIN sram_wdata_c[83] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
  END sram_wdata_c[83]
  PIN sram_wdata_c[82] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.227 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 9.7988 LAYER M4 ;
  END sram_wdata_c[82]
  PIN sram_wdata_c[81] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.677 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 11.7788 LAYER M4 ;
  END sram_wdata_c[81]
  PIN sram_wdata_c[80] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.087 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 9.1828 LAYER M4 ;
  END sram_wdata_c[80]
  PIN sram_wdata_c[79] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.933 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 17.2348 LAYER M4 ;
  END sram_wdata_c[79]
  PIN sram_wdata_c[78] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 4.707 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 20.7108 LAYER M4 ;
  END sram_wdata_c[78]
  PIN sram_wdata_c[77] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.377 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 14.8588 LAYER M4 ;
  END sram_wdata_c[77]
  PIN sram_wdata_c[76] 
    ANTENNADIFFAREA 0.9987 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.763 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 16.4868 LAYER M4 ;
  END sram_wdata_c[76]
  PIN sram_wdata_c[75] 
    ANTENNADIFFAREA 0.9987 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.557 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 11.2508 LAYER M4 ;
  END sram_wdata_c[75]
  PIN sram_wdata_c[74] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 4.047 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 17.8068 LAYER M4 ;
  END sram_wdata_c[74]
  PIN sram_wdata_c[73] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 1.957 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 8.6108 LAYER M4 ;
  END sram_wdata_c[73]
  PIN sram_wdata_c[72] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.167 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 9.5348 LAYER M4 ;
  END sram_wdata_c[72]
  PIN sram_wdata_c[71] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.213 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 14.0668 LAYER M4 ;
  END sram_wdata_c[71]
  PIN sram_wdata_c[70] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.003 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.1428 LAYER M4 ;
  END sram_wdata_c[70]
  PIN sram_wdata_c[69] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.313 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 14.5068 LAYER M4 ;
  END sram_wdata_c[69]
  PIN sram_wdata_c[68] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.763 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.0868 LAYER M4 ;
  END sram_wdata_c[68]
  PIN sram_wdata_c[67] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.053 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.3628 LAYER M4 ;
  END sram_wdata_c[67]
  PIN sram_wdata_c[66] 
    ANTENNADIFFAREA 0.728 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.387 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 14.9028 LAYER M4 ;
  END sram_wdata_c[66]
  PIN sram_wdata_c[65] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.173 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.8908 LAYER M4 ;
  END sram_wdata_c[65]
  PIN sram_wdata_c[64] 
    ANTENNADIFFAREA 0.728 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.991 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.1604 LAYER M4 ;
  END sram_wdata_c[64]
  PIN sram_wdata_c[63] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.117 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 9.3148 LAYER M4 ;
  END sram_wdata_c[63]
  PIN sram_wdata_c[62] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.987 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.1428 LAYER M4 ;
  END sram_wdata_c[62]
  PIN sram_wdata_c[61] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.417 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 10.6348 LAYER M4 ;
  END sram_wdata_c[61]
  PIN sram_wdata_c[60] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.707 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 11.9108 LAYER M4 ;
  END sram_wdata_c[60]
  PIN sram_wdata_c[59] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.097 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.6268 LAYER M4 ;
  END sram_wdata_c[59]
  PIN sram_wdata_c[58] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.627 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 11.5588 LAYER M4 ;
  END sram_wdata_c[58]
  PIN sram_wdata_c[57] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.977 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.0988 LAYER M4 ;
  END sram_wdata_c[57]
  PIN sram_wdata_c[56] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.847 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.5268 LAYER M4 ;
  END sram_wdata_c[56]
  PIN sram_wdata_c[55] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.897 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.7468 LAYER M4 ;
  END sram_wdata_c[55]
  PIN sram_wdata_c[54] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.787 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.2628 LAYER M4 ;
  END sram_wdata_c[54]
  PIN sram_wdata_c[53] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.737 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.0428 LAYER M4 ;
  END sram_wdata_c[53]
  PIN sram_wdata_c[52] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.587 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 11.3828 LAYER M4 ;
  END sram_wdata_c[52]
  PIN sram_wdata_c[51] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
  END sram_wdata_c[51]
  PIN sram_wdata_c[50] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.947 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.9668 LAYER M4 ;
  END sram_wdata_c[50]
  PIN sram_wdata_c[49] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.977 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 4.2988 LAYER M4 ;
  END sram_wdata_c[49]
  PIN sram_wdata_c[48] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.027 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.3188 LAYER M4 ;
  END sram_wdata_c[48]
  PIN sram_wdata_c[47] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.933 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.8348 LAYER M4 ;
  END sram_wdata_c[47]
  PIN sram_wdata_c[46] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 1.991 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 8.7604 LAYER M4 ;
  END sram_wdata_c[46]
  PIN sram_wdata_c[45] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.993 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.0988 LAYER M4 ;
  END sram_wdata_c[45]
  PIN sram_wdata_c[44] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.687 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 11.8228 LAYER M4 ;
  END sram_wdata_c[44]
  PIN sram_wdata_c[43] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.213 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 14.0668 LAYER M4 ;
  END sram_wdata_c[43]
  PIN sram_wdata_c[42] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.167 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 9.5348 LAYER M4 ;
  END sram_wdata_c[42]
  PIN sram_wdata_c[41] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.94 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.8656 LAYER M4 ;
  END sram_wdata_c[41]
  PIN sram_wdata_c[40] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.367 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 14.8148 LAYER M4 ;
  END sram_wdata_c[40]
  PIN sram_wdata_c[39] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.797 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.3068 LAYER M4 ;
  END sram_wdata_c[39]
  PIN sram_wdata_c[38] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.754 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.1176 LAYER M4 ;
  END sram_wdata_c[38]
  PIN sram_wdata_c[37] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.064 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 9.0816 LAYER M4 ;
  END sram_wdata_c[37]
  PIN sram_wdata_c[36] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.014 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.2616 LAYER M4 ;
  END sram_wdata_c[36]
  PIN sram_wdata_c[35] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.193 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.9788 LAYER M4 ;
  END sram_wdata_c[35]
  PIN sram_wdata_c[34] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.927 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.8788 LAYER M4 ;
  END sram_wdata_c[34]
  PIN sram_wdata_c[33] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 5.055 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 22.286 LAYER M4 ;
  END sram_wdata_c[33]
  PIN sram_wdata_c[32] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.014 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.2616 LAYER M4 ;
  END sram_wdata_c[32]
  PIN sram_wdata_c[31] 
    ANTENNADIFFAREA 1.005 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 6.569 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 28.9476 LAYER M4 ;
  END sram_wdata_c[31]
  PIN sram_wdata_c[30] 
    ANTENNADIFFAREA 1.005 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 6.179 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 27.2316 LAYER M4 ;
  END sram_wdata_c[30]
  PIN sram_wdata_c[29] 
    ANTENNADIFFAREA 1.005 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.789 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.3156 LAYER M4 ;
  END sram_wdata_c[29]
  PIN sram_wdata_c[28] 
    ANTENNADIFFAREA 1.005 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.599 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 15.8796 LAYER M4 ;
  END sram_wdata_c[28]
  PIN sram_wdata_c[27] 
    ANTENNADIFFAREA 1.005 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.405 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 14.9556 LAYER M4 ;
  END sram_wdata_c[27]
  PIN sram_wdata_c[26] 
    ANTENNADIFFAREA 1.005 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.319 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 14.6476 LAYER M4 ;
  END sram_wdata_c[26]
  PIN sram_wdata_c[25] 
    ANTENNADIFFAREA 1.005 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.029 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 8.9716 LAYER M4 ;
  END sram_wdata_c[25]
  PIN sram_wdata_c[24] 
    ANTENNADIFFAREA 1.005 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.939 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 17.3756 LAYER M4 ;
  END sram_wdata_c[24]
  PIN sram_wdata_c[23] 
    ANTENNADIFFAREA 1.005 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.249 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 14.3396 LAYER M4 ;
  END sram_wdata_c[23]
  PIN sram_wdata_c[22] 
    ANTENNADIFFAREA 1.005 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 5.819 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 25.6476 LAYER M4 ;
  END sram_wdata_c[22]
  PIN sram_wdata_c[21] 
    ANTENNADIFFAREA 1.005 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 6.369 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 28.0676 LAYER M4 ;
  END sram_wdata_c[21]
  PIN sram_wdata_c[20] 
    ANTENNADIFFAREA 1.005 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 4.299 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 18.9596 LAYER M4 ;
  END sram_wdata_c[20]
  PIN sram_wdata_c[19] 
    ANTENNADIFFAREA 1.005 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 7.756 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 34.2144 LAYER M4 ;
  END sram_wdata_c[19]
  PIN sram_wdata_c[18] 
    ANTENNADIFFAREA 0.9987 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 4.215 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 18.5196 LAYER M4 ;
  END sram_wdata_c[18]
  PIN sram_wdata_c[17] 
    ANTENNADIFFAREA 0.9987 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.809 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.4036 LAYER M4 ;
  END sram_wdata_c[17]
  PIN sram_wdata_c[16] 
    ANTENNADIFFAREA 0.9987 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.839 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 16.9356 LAYER M4 ;
  END sram_wdata_c[16]
  PIN sram_wdata_c[15] 
    ANTENNADIFFAREA 0.9987 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.529 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 15.5716 LAYER M4 ;
  END sram_wdata_c[15]
  PIN sram_wdata_c[14] 
    ANTENNADIFFAREA 0.9987 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 8.121 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 35.8204 LAYER M4 ;
  END sram_wdata_c[14]
  PIN sram_wdata_c[13] 
    ANTENNADIFFAREA 1.005 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 17.069 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 75.1476 LAYER M4 ;
  END sram_wdata_c[13]
  PIN sram_wdata_c[12] 
    ANTENNADIFFAREA 0.9987 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.999 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.2396 LAYER M4 ;
  END sram_wdata_c[12]
  PIN sram_wdata_c[11] 
    ANTENNADIFFAREA 1.005 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 9.449 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 41.6196 LAYER M4 ;
  END sram_wdata_c[11]
  PIN sram_wdata_c[10] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.957 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.0284 LAYER M4 ;
  END sram_wdata_c[10]
  PIN sram_wdata_c[9] 
    ANTENNADIFFAREA 0.9987 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.589 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 15.8356 LAYER M4 ;
  END sram_wdata_c[9]
  PIN sram_wdata_c[8] 
    ANTENNADIFFAREA 0.9987 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 4.119 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 18.1676 LAYER M4 ;
  END sram_wdata_c[8]
  PIN sram_wdata_c[7] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.038 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2112 LAYER M4 ;
  END sram_wdata_c[7]
  PIN sram_wdata_c[6] 
    ANTENNADIFFAREA 0.9987 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.019 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.3276 LAYER M4 ;
  END sram_wdata_c[6]
  PIN sram_wdata_c[5] 
    ANTENNADIFFAREA 0.9987 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.949 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 17.4196 LAYER M4 ;
  END sram_wdata_c[5]
  PIN sram_wdata_c[4] 
    ANTENNADIFFAREA 0.9987 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 4.119 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 18.1676 LAYER M4 ;
  END sram_wdata_c[4]
  PIN sram_wdata_c[3] 
    ANTENNADIFFAREA 0.9987 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.729 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 16.4516 LAYER M4 ;
  END sram_wdata_c[3]
  PIN sram_wdata_c[2] 
    ANTENNADIFFAREA 0.9987 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 2.819 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.4476 LAYER M4 ;
  END sram_wdata_c[2]
  PIN sram_wdata_c[1] 
    ANTENNADIFFAREA 0.9987 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.709 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 16.3636 LAYER M4 ;
  END sram_wdata_c[1]
  PIN sram_wdata_c[0] 
    ANTENNADIFFAREA 0.9987 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 5.399 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 23.7996 LAYER M4 ;
  END sram_wdata_c[0]
  PIN out_ready 
    ANTENNADIFFAREA 1.349 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 6.379 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 28.1116 LAYER M4 ;
  END out_ready
  PIN row_idx[2] 
    ANTENNADIFFAREA 1.005 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 6.429 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 28.3316 LAYER M4 ;
  END row_idx[2]
  PIN row_idx[1] 
    ANTENNADIFFAREA 1.005 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 6.139 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 27.0556 LAYER M4 ;
  END row_idx[1]
  PIN row_idx[0] 
    ANTENNADIFFAREA 1.092 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.977 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 4.2988 LAYER M4 ;
  END row_idx[0]
END systolic_array_wrapper

END LIBRARY
